# Repository hringdrifi/skjar

File README.md:

# SKJÁR

**SKJÁR** は、横長のタッチディスプレイと小型 Linux コンピュータを一体にした、40% のメカニカルキーボード / Cyberdeck です。

物理キーは文字入力に必要な最小限にとどめ、数字列・F キー・マクロ・メディア操作・ステータス表示などはタッチディスプレイ側に持たせます。PC につなげば普通の USB キーボードとして動き、本体側では Linux のアプリケーションが動きます。

> [!WARNING]
> **開発中のプロジェクトです。** 回路図・基板はまだ試作も動作確認もしていません。誤りが含まれている可能性が高いので、**このままの設計データで基板を発注したり、部品を買いそろえたりしないでください。** 内容は予告なく大きく変わります。

**状態：** 回路図を作成中。基板は部品の仮置きまで（配線は未着手）。決めたことは [docs/design-decisions.md](docs/design-decisions.md)、残っていることは [docs/open-items.md](docs/open-items.md) にあります。

---

## 名前の由来

古ノルド語の `skjár` から取りました。中世アイスランドで、半透明の膜を張った採光用の窓を指した言葉です。現代アイスランド語では「screen / display」を意味します。横長のディスプレイを主役にした本機に合わせた名前です。

---

## 設計思想

SKJÁR では、ディスプレイを「おまけ」として扱いません。物理キーとタッチ UI を合わせて、1つの入力システムにします。

一般的な 60% キーボードに画面を足すのではなく、

**必要最小限の物理キー ＋ 状況に応じて変わるソフトウェアキー**

という構成を基本にします。

---

## コンセプト

- 40% のコンパクトな物理キーボード
- 上部に 8.8″ の横長タッチディスプレイ
- Linux を搭載
- PC からは普通の USB HID キーボードとして見える
- 本体の Linux からも普通のキーボードとして見える（HID over I²C。素の Raspberry Pi OS のドライバで動く）
- キーごとの RGB バックライト
- タッチ UI を物理キーの拡張として使う
- Cyberdeck 的な自由度
- ケーブル1本でも全機能が動く（相手が 5 V / 1.5 A 以上を出せる場合）

---

## 構成

| 部分 | 内容 |
|---|---|
| メインコンピュータ | Raspberry Pi Compute Module 0（CM0100000：CM0Lite、Cortex-A53 ×4 / 1 GHz、512 MB、Wi-Fi / BT）。microSD から起動 |
| キーボード用マイコン | RP2040（PC への USB HID、CM0 への HID over I²C、キーの RGB、電源の判断、CC の判定） |
| キー | Kailh Choc V2 系（ホットスワップ）×42。キーごとに RGB LED（SK6812MINI-E） |
| ディスプレイ | Waveshare 8.8inch DSI LCD または 8.8-DSI-TOUCH-A（480×1920、10点タッチ、DSI 2レーン） |
| 電源 | USB-C ×2、5 V 専用（PD なし）、上限 15 W。TPS2121 で切り替え |
| RTC | PCF8563T ＋ 32.768 kHz 水晶 ＋ CR2032 |
| 音声 | TLV320DAC3100（I²S コーデック。スピーカーアンプとイヤホン出力を内蔵）＋ スピーカー ＋ 3.5 mm イヤホンジャック |
| OS | Raspberry Pi OS Lite。デスクトップ環境は使わず、専用 UI を直接起動する。カーネルとドライバは標準のまま、オーバーレイと `config.txt` だけで大体の機能が動くようにする |

詳しい仕様と理由は [docs/design-decisions.md](docs/design-decisions.md) を見てください。

---

## タッチ UI でやりたいこと

数字列、F1〜F12、マクロキー、レイヤーの表示と切り替え、メディア操作、音量スライダー、輝度調整、アプリランチャー、PC のステータス表示、時計、CPU / RAM / ネットワークの表示、WPM 表示、アニメーション、動画再生、トラックパッドモード、ジェスチャ入力、アプリごとに変わる UI。

---

## リポジトリの構成

```text
README.md                 この文書
LICENSE, LICENSES/        ライセンスの説明と全文
docs/                     文書（CC BY-SA 4.0）
├─ design-decisions.md    設計判断の記録
├─ open-items.md          残件
├─ protocol.md            RP2040 ↔ CM0 の通信仕様
├─ pin-assignment.md      ピンの割り当てとシート間の信号
├─ schematic/             回路図のシートごとの仕様（部品、接続、定数）
├─ images/                図（構成図など）
└─ references/README.md   参照した一次資料の出典と要点
hardware/                 ハードウェア（CERN-OHL-S-2.0）
├─ pcb/                   KiCad 10 のプロジェクト（lib/：専用部品、production/：製造用データ）
├─ layout/                キー配列
└─ case/                  ケース
firmware/                 ファームウェア（MIT）
└─ rp2040/                キーボードと電源管理
software/                 CM0 側のソフトウェア（MIT）
├─ ui/                    専用 UI
└─ os/                    OS の設定とイメージ作成
```

他社の資料（データシート、図面、技適の試験成績書など）は、著作権の都合でリポジトリに含めていません。出典のリンクは [docs/references/README.md](docs/references/README.md) にあります。

---

## ライセンス

| 対象 | ライセンス |
|---|---|
| ハードウェア（回路図、基板、ケースの設計データ） | [CERN-OHL-S-2.0](LICENSES/CERN-OHL-S-2.0.txt) |
| ソフトウェア（ファームウェア、UI、スクリプト） | [MIT](LICENSES/MIT.txt) |
| 文書（この README と docs/ 以下） | [CC BY-SA 4.0](LICENSES/CC-BY-SA-4.0.txt) |

詳しくは [LICENSE](LICENSE) を見てください。

## KiCad design hardware/pcb/skjar.kicad_pcb

File hardware/pcb/README.md:

# pcb

KiCad 10 のプロジェクト。**KiCad 10 で開いて保存すること**（古いバージョンで保存すると、ファイル形式の違いで問題が起きることがある）。

## 回路図のシート構成

| シート | 内容 | 仕様 |
|---|---|---|
| `skjar.kicad_sch` | 最上位のシート | |
| `power.kicad_sch` | USB-C ×2、TPS2121、CC の判定、負荷スイッチ、3.3 V のレギュレータ | [power.md](../../docs/schematic/power.md) |
| `rp2040.kicad_sch` | RP2040 とその周辺（フラッシュ、水晶、USB、テストパッド） | [rp2040.md](../../docs/schematic/rp2040.md) |
| `cm0.kicad_sch` | Compute Module 0、microSD、UART のバッファ、キー入力の I²C のプルアップ | [cm0.md](../../docs/schematic/cm0.md) |
| `display.kicad_sch` | 22ピン FPC コネクタ、LCD の電源 | [display.md](../../docs/schematic/display.md) |
| `peripherals.kicad_sch` | RTC、音声（TLV320DAC3100、12 MHz の発振器、スピーカー、イヤホンジャック） | [peripherals.md](../../docs/schematic/peripherals.md) |
| `keymatrix.kicad_sch` | キーマトリクス、キーの RGB（SK6812MINI-E ×42、電源スイッチ、バッファ） | [keymatrix.md](../../docs/schematic/keymatrix.md) |

設計の前提は [docs/design-decisions.md](../../docs/design-decisions.md) を参照。

## フォルダ

| フォルダ | 内容 |
|---|---|
| [lib/](lib/) | このプロジェクト専用のシンボルとフットプリント |
| [production/](production/) | 製造用データ（ガーバー、BOM、CPL） |

Parts:
C1, C2, C7, C10, C11, C15: 1u; C_0603_1608Metric; LCSC C15849
C3, C12, C13, C14: 100n; C_0603_1608Metric; LCSC C14663
C4: 470u; CP_Elec_6.3x7.7; LCSC C46550459
C5, C6, C9, C16: 10u; C_0603_1608Metric; LCSC C96446
C8: 1n; C_0603_1608Metric; LCSC C1588
D1: B5819W; D_SOD-123; LCSC C8598
J1: USB-C Port B; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J2: USB-C Port A; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
Q1, Q2, Q3: 2N7002; SOT-23; LCSC C8545
R1, R2: 5.1k 1%; R_0603_1608Metric; LCSC C23186; not fitted
R3, R4: 5.1k 1%; R_0603_1608Metric; LCSC C23186
R5, R7, R9, R11, R15: 100k; R_0603_1608Metric; LCSC C25803
R6: 51k; R_0603_1608Metric; LCSC C23196
R8, R12: 22k; R_0603_1608Metric; LCSC C31850
R10: 43k; R_0603_1608Metric; LCSC C23172
R13: 30k 1%; R_0603_1608Metric; LCSC C22984
R14, R17, R18: 10k; R_0603_1608Metric; LCSC C25804
R16: 910k 1%; R_0603_1608Metric; LCSC C23263
R19: 6.8k; R_0603_1608Metric; LCSC C23212
TP1: PWR_ST; TestPoint_Pad_D1.5mm
U1, U2: USBLC6-2SC6; SOT-23-6; LCSC C7519
U3: TPS2121RUX; Texas_RUX_VQFN-HR-12_2.5x2mm_P0.5mm; MPN TPS2121RUXR; LCSC C485916
U4: TPS22965DSG; Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; MPN TPS22965DSGR; LCSC C122837
U5: AP2127N-3.3; SOT-23-3; LCSC C176954
U6: TUSB320LAI; Texas_X2QFN-12_1.6x1.6mm_P0.4mm; MPN TUSB320LAIRWBR; LCSC C132554
U7: SN74LVC1G04DBVR; SOT-23-5; LCSC C7827
U8: SN74LVC1G02DBVR; SOT-23-5; MPN SN74LVC1G02DBVR(UMW); LCSC C7394016
U9: SY6280AAC; SOT-23-5; LCSC C55136

Connections:
+3V3: C11.1, C12.1, C13.1, C14.1, R14.1, R17.1, U5.2 (VO), U6.12 (VDD), U7.5 (VCC), U8.5 (VCC); also elsewhere on the board
+3V3_CM0: Q1.1 (G), R18.1; also elsewhere on the board
+5V: C4.1, C5.1, C6.1, C7.1, C10.1, C15.1, U1.5 (VBUS), U2.5 (VBUS), U3.1 (OUT), U3.8 (OUT), U4.1 (VIN), U4.2 (VIN), U4.4 (VBIAS), U5.3 (VI), U9.5 (IN); also elsewhere on the board
+5V_LCD: C9.1, U4.7 (VOUT), U4.8 (VOUT); also elsewhere on the board
/Power Sheet/HOST_B: Q2.1 (G), Q3.1 (G), U7.4
/Power Sheet/PR1_B: Q2.3 (D), R5.2, R6.1, U3.6 (PR1)
/Power Sheet/SY_ISET: R19.1, U9.3 (ISET)
/Power Sheet/TUSB_EN_N: Q1.3 (D), U6.11 (~EN)
/Power Sheet/TUSB_ID: R17.2, U6.9 (ID), U7.2, U8.1
/Power Sheet/TUSB_VDET: R16.2, U6.4 (VBUS_DET)
/Power Sheet/VBUS_B_EN: U8.4, U9.4 (EN)
CC1_A: J2.A5 (CC1), R3.1; also elsewhere on the board
CC1_B: J1.A5 (CC1), R1.1, U6.1 (CC1); also elsewhere on the board
CC2_A: J2.B5 (CC2), R4.1; also elsewhere on the board
CC2_B: J1.B5 (CC2), R2.1, U6.2 (CC2); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), Q1.2 (S), Q2.2 (S), Q3.2 (S), R1.2, R2.2, R3.2, R4.2, R6.2, R8.2, R10.2, R12.2, R13.2, R15.2, R19.2, U1.2 (GND), U2.2 (GND), U3.12 (GND), U4.5 (GND), U4.9 (GND), U5.1 (GND), U6.3 (PORT), U6.5 (ADDR), U6.10 (GND), U7.3 (GND), U8.3 (GND), U9.2 (GND); also elsewhere on the board
I2C1_SCL: U6.8 (SCL/OUT2); also elsewhere on the board
I2C1_SDA: U6.7 (SDA/OUT1); also elsewhere on the board
LCD_EN: R15.1, U4.3 (ON); also elsewhere on the board
unnamed: C16.1, D1.2 (A), U9.1 (OUT)
unnamed: R9.2, R10.1, U3.3 (CP2)
unnamed: R13.1, U3.10 (ILM)
unnamed: R7.2, R8.1, U3.5 (OV1)
unnamed: R11.2, R12.1, U3.4 (OV2)
unnamed: C3.1, U3.11 (SS)
unnamed: C8.1, U4.6 (CT)
PWR_ST: R14.2, TP1.1 (1_1), U3.9 (ST), U8.2; also elsewhere on the board
TUSB_INT: R18.2, U6.6 (~INT/OUT3); also elsewhere on the board
USB_A_D+: J2.A6 (D+), J2.B6 (D+), U2.1 (I/O1), U2.6 (I/O1); also elsewhere on the board
USB_A_D-: J2.A7 (D-), J2.B7 (D-), U2.3 (I/O2), U2.4 (I/O2); also elsewhere on the board
USB_B_D+: J1.A6 (D+), J1.B6 (D+), U1.1 (I/O1), U1.6 (I/O1); also elsewhere on the board
USB_B_D-: J1.A7 (D-), J1.B7 (D-), U1.3 (I/O2), U1.4 (I/O2); also elsewhere on the board
USB_OTG: Q3.3 (D); also elsewhere on the board
VBUS_A: C2.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R9.1, R11.1, U3.2 (IN2)
VBUS_B: C1.1, D1.1 (K), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R5.1, R7.1, R16.1, U3.7 (IN1)

Notes on the sheet:
Port B のホスト（DRP、TUSB320）
常時 ON 3.3V
Port A
USB-C ×2 から +5V を作る。Port B（IN1）を優先し、TPS2121 が自動で切り替える（ST が High なら B、Low なら A から給電）。 CC の 5.1 kΩ でデバイスとして 5 V を受ける。CC の電圧は RP2040 の ADC で読む（rp2040 シートの R107〜R110）。 +3V3 は常時 ON（RP2040 と RTC 用）。+5V_LCD は RP2040 の LCD_EN で ON / OFF する。 詳細：docs/schematic/power.md
LCD 電源 TPS22965
テストパッド
サイバーデッキモードで、CM0 が I²C で U6 を DRP（Try.SNK）にする。 機器が挿さると U6 が ID を Low にし、U7 が HOST_B を High にする。 Q2：PR1 を GND に引く（TPS2121 は Port A を使う） Q3：CM0 の USB_OTG を GND に引く（CM0 が USB ホストになる） U8：ID が Low で PWR_ST も Low（Port A から給電）のときだけ、 U9 で VBUS_B に 5 V を出す（1.0 A で電流制限） CM0 が OFF の間は Q1 が切れて U6 は止まり、Rd だけを出す。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
電源切り替え TPS2121
Port B（IN1 優先）

Parts:
C201, C205: 10u; C_0603_1608Metric; LCSC C96446
C202, C203, C204: 100n; C_0603_1608Metric; LCSC C14663
C206: 0.1F 5.5V; CP_EDLC_10x5mm_P7.50mm_Horizontal; MPN CHP5R5L104R-TW
C207, C208: 1u; C_0603_1608Metric; LCSC C15849
D201, D202: B5819W; D_SOD-123; LCSC C8598
J201: microSD; microSD_HRO_TF-01A; LCSC C91145
JP201: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q201, Q202: 2N7002; SOT-23; LCSC C8545
R201, R210: 10k; R_0603_1608Metric; LCSC C25804
R202: 100k; R_0603_1608Metric; LCSC C25803
R208, R209: 4.7k; R_0603_1608Metric; LCSC C23162
R211: 100; R_1206_3216Metric; LCSC C17901
TP201: CM0_RUN_PG; TestPoint_Pad_D1.5mm
TP202: GLOBAL_EN; TestPoint_Pad_D1.5mm
TP203: NRPI_BOOT; TestPoint_Pad_D1.5mm
TP204: CM0_TXD; TestPoint_Pad_D1.5mm
TP205: CM0_RXD; TestPoint_Pad_D1.5mm
TP206: CM0_ACT; TestPoint_Pad_D1.5mm
TP207: WIFI_ON; TestPoint_Pad_D1.5mm
TP208: BT_ON; TestPoint_Pad_D1.5mm
U201: CM0100000; RaspberryPi_CM0_Castellated; MPN CM0100000
U202: SN74LVC1G125DBV; SOT-23-5; LCSC C23654
U203: AP2127K-3.3; SOT-23-5; LCSC C156285
U204: APX809S05-31SA-7; SOT-23; LCSC C2067622

Connections:
+1V8_CM0: U201.64 (CM0_1.8V), U201.65 (CM0_1.8V); also elsewhere on the board
+3V3: R201.1; also elsewhere on the board
+3V3_CM0: C203.1, JP201.1 (A), R208.1, R209.1, R210.1, U201.41 (CM0_3.3V), U201.119 (CM0_3.3V), U201.120 (GPIO_VREF), U201.122 (SD_VREF), U202.5 (VCC); also elsewhere on the board
+3V3_SD: C204.1, C205.1, C208.1, J201.4 (VDD), JP201.2 (B), U203.5 (VOUT)
+5V: C201.1, C202.1, D201.2 (A), U201.67 (5V), U201.68 (5V); also elsewhere on the board
/CM0 Sheet/BT_ON: TP208.1 (1_1), U201.117 (BT_ON)
/CM0 Sheet/CM0_ACT: TP206.1 (1_1), U201.118 (LED_nACT)
/CM0 Sheet/CM0_RXD: TP205.1 (1_1), U201.108 (GPIO15), U202.4
/CM0 Sheet/GLOBAL_EN: Q201.3 (D), TP202.1 (1_1), U201.62 (GLOBAL_EN)
/CM0 Sheet/NRPI_BOOT: Q202.3 (D), TP203.1 (1_1), U201.121 (nRPI_BOOT)
/CM0 Sheet/SD_CLK: J201.5 (CLK), U201.127 (SD_CLK)
/CM0 Sheet/SD_CMD: J201.3 (CMD), U201.128 (SD_CMD)
/CM0 Sheet/SD_DAT0: J201.7 (DAT0), U201.125 (SD_DAT0)
/CM0 Sheet/SD_DAT1: J201.8 (DAT1), U201.124 (SD_DAT1)
/CM0 Sheet/SD_DAT2: J201.1 (DAT2), U201.131 (SD_DAT2)
/CM0 Sheet/SD_DAT3: J201.2 (DAT3/CD), U201.130 (SD_DAT3)
/CM0 Sheet/SD_EN: U203.3 (EN), U204.2 (~RESET)
/CM0 Sheet/SD_HOLD: C206.1, D202.2 (A), R211.2
/CM0 Sheet/SD_VIN: C207.1, D201.1 (K), D202.1 (K), R211.1, U203.1 (VIN), U204.3 (V_{DD})
/CM0 Sheet/WIFI_ON: TP207.1 (1_1), U201.116 (WiFi_ON)
BOOT_EN: Q202.1 (G), R202.1; also elsewhere on the board
CM0_HALT: U201.97 (GPIO10); also elsewhere on the board
CM0_PWROFF: Q201.1 (G), R201.2; also elsewhere on the board
CM0_RUN_PG: TP201.1 (1_1), U201.61 (RUN_PG); also elsewhere on the board
CM0_TXD: TP204.1 (1_1), U201.110 (GPIO14); also elsewhere on the board
CODEC_RST: U201.102 (GPIO22); also elsewhere on the board
DSI_CK_N: U201.9 (DSI_CK_N); also elsewhere on the board
DSI_CK_P: U201.8 (DSI_CK_P); also elsewhere on the board
DSI_D0_N: U201.15 (DSI_D0_N); also elsewhere on the board
DSI_D0_P: U201.14 (DSI_D0_P); also elsewhere on the board
DSI_D1_N: U201.12 (DSI_D1_N); also elsewhere on the board
DSI_D1_P: U201.11 (DSI_D1_P); also elsewhere on the board
DSI_D2_N: U201.6 (DSI_D2_N); also elsewhere on the board
DSI_D2_P: U201.5 (DSI_D2_P); also elsewhere on the board
DSI_D3_N: U201.3 (DSI_D3_N); also elsewhere on the board
DSI_D3_P: U201.2 (DSI_D3_P); also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, J201.6 (VSS), J201.SH (SHIELD), Q201.2 (S), Q202.2 (S), R202.2, U201.1 (GND), U201.4 (GND), U201.7 (GND), U201.10 (GND), U201.13 (GND), U201.16 (GND), U201.21 (GND), U201.24 (GND), U201.27 (GND), U201.30 (GND), U201.33 (GND), U201.34 (GND), U201.37 (GND), U201.40 (GND), U201.45 (GND), U201.48 (GND), U201.51 (GND), U201.54 (GND), U201.57 (GND), U201.60 (GND), U201.63 (GND), U201.66 (GND), U201.69 (GND), U201.72 (GND), U201.75 (GND), U201.78 (GND), U201.81 (GND), U201.84 (GND), U201.87 (GND), U201.90 (GND), U201.93 (GND), U201.96 (GND), U201.99 (GND), U201.100 (GND), U201.103 (GND), U201.106 (GND), U201.109 (GND), U201.112 (GND), U201.115 (GND), U201.123 (GND), U201.126 (GND), U201.129 (GND), U201.132 (GND), U202.1, U202.3 (GND), U203.2 (GND), U204.1 (GND); also elsewhere on the board
HP_DET: U201.107 (GPIO17); also elsewhere on the board
I2C1_SCL: U201.113 (GPIO3); also elsewhere on the board
I2C1_SDA: U201.114 (GPIO2); also elsewhere on the board
I2C_DSI_SCL: U201.43 (SCL0); also elsewhere on the board
I2C_DSI_SDA: U201.42 (SDA0); also elsewhere on the board
I2S_BCLK: U201.105 (GPIO18); also elsewhere on the board
I2S_DIN: U201.74 (GPIO20); also elsewhere on the board
I2S_DOUT: U201.73 (GPIO21); also elsewhere on the board
I2S_LRCLK: U201.79 (GPIO19); also elsewhere on the board
KB_INT: R210.2, U201.94 (GPIO25); also elsewhere on the board
KB_SCL: R209.2, U201.98 (GPIO24); also elsewhere on the board
KB_SDA: R208.2, U201.101 (GPIO23); also elsewhere on the board
RP_TXD: U202.2; also elsewhere on the board
RTC_INT: U201.104 (GPIO27); also elsewhere on the board
TUSB_INT: U201.83 (GPIO6); also elsewhere on the board
USB_B_D+: U201.36 (USB_P); also elsewhere on the board
USB_B_D-: U201.35 (USB_N); also elsewhere on the board
USB_OTG: U201.38 (USB_OTG); also elsewhere on the board

Notes on the sheet:
+5V が切れると D201 が切り離し、C206 の電気で U203 が +3V3_SD を出し続ける。 カードは書き込み中の作業を終えられる（100 mA で約 0.5 秒）。 SD_VIN が 3.08 V を下回ると U204 が U203 を止め、電圧がだらだら下がらないよう、すぱっと切る。 C206・R211・D202 は外してもよい（持たないだけで動く）。 U203 を外すときは JP201 を閉じる（U203 を載せたまま閉じると、U203 と CM0 の 3.3V がぶつかる）。 電源を入れてから U204 が U203 を ON にするまで 240 ms 以上かかる。RP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
nRPI_BOOT（RP2040 から要求）
UART の受信バッファ（+3V3_CM0 で動作）
GLOBAL_EN（初期状態は OFF）
CM0：ディスプレイ / カメラ（DSI と I2C だけ使う）
SD カードの電源（電源が切れても 0.5 秒持たせる）
CM0：システム
CM0：GPIO
テストパッド
CM0：電源
CM0 が OFF（+3V3_CM0 = 0 V）のときに電流を流し込まないよう、RP2040 とつながる線のプルアップは +3V3_CM0 側に置き、 UART の受信は Ioff 付きのバッファ（U202）を通す。 GLOBAL_EN は CM0 の内部で 5 V にプルアップされているので、Q201 で Low に引く。初期状態は OFF。 SD の CMD / DAT0〜3 に外付けのプルアップはない（CM4IO と同じ。SoC の内部プルアップを使う）。 詳細：docs/schematic/cm0.md
