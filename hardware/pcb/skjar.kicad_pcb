# Repository hringdrifi/skjar

File README.md:

# SKJÁR

**SKJÁR** は、横長のタッチディスプレイと小型 Linux コンピュータを一体にした、40% のメカニカルキーボード / Cyberdeck です。

物理キーは文字入力に必要な最小限にとどめ、数字列・F キー・マクロ・メディア操作・ステータス表示などはタッチディスプレイ側に持たせます。PC につなげば普通の USB キーボードとして動き、本体側では Linux のアプリケーションが動きます。

> [!WARNING]
> **開発中のプロジェクトです。** 回路図・基板はまだ試作も動作確認もしていません。誤りが含まれている可能性が高いので、**このままの設計データで基板を発注したり、部品を買いそろえたりしないでください。** 内容は予告なく大きく変わります。

**状態：** 回路図を作成中。基板は部品の仮置きまで（配線は未着手）。決めたことは [docs/design-decisions.md](docs/design-decisions.md)、残っていることは [docs/open-items.md](docs/open-items.md) にあります。

---

## 名前の由来

古ノルド語の `skjár` から取りました。中世アイスランドで、半透明の膜を張った採光用の窓を指した言葉です。現代アイスランド語では「screen / display」を意味します。横長のディスプレイを主役にした本機に合わせた名前です。

---

## 設計思想

SKJÁR では、ディスプレイを「おまけ」として扱いません。物理キーとタッチ UI を合わせて、1つの入力システムにします。

一般的な 60% キーボードに画面を足すのではなく、

**必要最小限の物理キー ＋ 状況に応じて変わるソフトウェアキー**

という構成を基本にします。

---

## コンセプト

- 40% のコンパクトな物理キーボード
- 上部に 8.8″ の横長タッチディスプレイ
- Linux を搭載
- PC からは普通の USB HID キーボードとして見える
- 本体の Linux からも普通のキーボードとして見える（HID over I²C。素の Raspberry Pi OS のドライバで動く）
- キーごとの RGB バックライト
- タッチ UI を物理キーの拡張として使う
- Cyberdeck 的な自由度
- ケーブル1本でも全機能が動く（相手が 5 V / 1.5 A 以上を出せる場合）

---

## 構成

| 部分 | 内容 |
|---|---|
| メインコンピュータ | Raspberry Pi Compute Module 0（CM0100000：CM0Lite、Cortex-A53 ×4 / 1 GHz、512 MB、Wi-Fi / BT）。microSD から起動 |
| キーボード用マイコン | RP2040（PC への USB HID、CM0 への HID over I²C、キーの RGB、電源の判断、CC の判定） |
| キー | Kailh Choc V2 系（ホットスワップ）×42。キーごとに RGB LED（SK6812MINI-E） |
| ディスプレイ | Waveshare 8.8inch DSI LCD または 8.8-DSI-TOUCH-A（480×1920、10点タッチ、DSI 2レーン） |
| 電源 | USB-C ×2、5 V 専用（PD なし）、上限 15 W。TPS2121 で切り替え |
| RTC | PCF8563T ＋ 32.768 kHz 水晶 ＋ CR2032 |
| 音声 | TLV320DAC3100（I²S コーデック。スピーカーアンプとイヤホン出力を内蔵）＋ スピーカー ＋ 3.5 mm イヤホンジャック |
| OS | Raspberry Pi OS Lite。デスクトップ環境は使わず、専用 UI を直接起動する。カーネルとドライバは標準のまま、オーバーレイと `config.txt` だけで大体の機能が動くようにする |

詳しい仕様と理由は [docs/design-decisions.md](docs/design-decisions.md) を見てください。

---

## タッチ UI でやりたいこと

数字列、F1〜F12、マクロキー、レイヤーの表示と切り替え、メディア操作、音量スライダー、輝度調整、アプリランチャー、PC のステータス表示、時計、CPU / RAM / ネットワークの表示、WPM 表示、アニメーション、動画再生、トラックパッドモード、ジェスチャ入力、アプリごとに変わる UI。

---

## リポジトリの構成

```text
README.md                 この文書
LICENSE, LICENSES/        ライセンスの説明と全文
docs/                     文書（CC BY-SA 4.0）
├─ design-decisions.md    設計判断の記録
├─ open-items.md          残件
├─ protocol.md            RP2040 ↔ CM0 の通信仕様
├─ pin-assignment.md      ピンの割り当てとシート間の信号
├─ schematic/             回路図のシートごとの仕様（部品、接続、定数）
├─ images/                図（構成図など）
└─ references/README.md   参照した一次資料の出典と要点
hardware/                 ハードウェア（CERN-OHL-S-2.0）
├─ pcb/                   KiCad 10 のプロジェクト（lib/：専用部品、production/：製造用データ）
├─ layout/                キー配列
└─ case/                  ケース
firmware/                 ファームウェア（MIT）
└─ rp2040/                キーボードと電源管理
software/                 CM0 側のソフトウェア（MIT）
├─ ui/                    専用 UI
└─ os/                    OS の設定とイメージ作成
```

他社の資料（データシート、図面、技適の試験成績書など）は、著作権の都合でリポジトリに含めていません。出典のリンクは [docs/references/README.md](docs/references/README.md) にあります。

---

## ライセンス

| 対象 | ライセンス |
|---|---|
| ハードウェア（回路図、基板、ケースの設計データ） | [CERN-OHL-S-2.0](LICENSES/CERN-OHL-S-2.0.txt) |
| ソフトウェア（ファームウェア、UI、スクリプト） | [MIT](LICENSES/MIT.txt) |
| 文書（この README と docs/ 以下） | [CC BY-SA 4.0](LICENSES/CC-BY-SA-4.0.txt) |

詳しくは [LICENSE](LICENSE) を見てください。

## KiCad design hardware/pcb/skjar.kicad_pcb

File hardware/pcb/README.md:

# pcb

KiCad 10 のプロジェクト。**KiCad 10 で開いて保存すること**（古いバージョンで保存すると、ファイル形式の違いで問題が起きることがある）。

## 回路図のシート構成

| シート | 内容 | 仕様 |
|---|---|---|
| `skjar.kicad_sch` | 最上位のシート | |
| `power.kicad_sch` | USB-C ×2、TPS2121、CC の判定、負荷スイッチ、3.3 V のレギュレータ | [power.md](../../docs/schematic/power.md) |
| `rp2040.kicad_sch` | RP2040 とその周辺（フラッシュ、水晶、USB、テストパッド） | [rp2040.md](../../docs/schematic/rp2040.md) |
| `cm0.kicad_sch` | Compute Module 0、microSD、UART のバッファ、キー入力の I²C のプルアップ | [cm0.md](../../docs/schematic/cm0.md) |
| `display.kicad_sch` | 22ピン FPC コネクタ、LCD の電源 | [display.md](../../docs/schematic/display.md) |
| `peripherals.kicad_sch` | RTC、音声（TLV320DAC3100、12 MHz の発振器、スピーカー、イヤホンジャック） | [peripherals.md](../../docs/schematic/peripherals.md) |
| `keymatrix.kicad_sch` | キーマトリクス、キーの RGB（SK6812MINI-E ×42、電源スイッチ、バッファ） | [keymatrix.md](../../docs/schematic/keymatrix.md) |

設計の前提は [docs/design-decisions.md](../../docs/design-decisions.md) を参照。

## フォルダ

| フォルダ | 内容 |
|---|---|
| [lib/](lib/) | このプロジェクト専用のシンボルとフットプリント |
| [production/](production/) | 製造用データ（ガーバー、BOM、CPL） |

Parts:
C1, C2, C7, C10, C11: 1u; C_0603_1608Metric; LCSC C15849
C3: 100n; C_0603_1608Metric; LCSC C14663
C4: 470u; CP_Elec_6.3x7.7; LCSC C46550459
C5, C6, C9: 10u; C_0603_1608Metric; LCSC C96446
C8: 1n; C_0603_1608Metric; LCSC C1588
J1: USB-C Port B; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J2: USB-C Port A; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
R1, R2, R3, R4: 5.1k 1%; R_0603_1608Metric; LCSC C23186
R5, R7, R9, R11, R15: 100k; R_0603_1608Metric; LCSC C25803
R6: 51k; R_0603_1608Metric; LCSC C23196
R8, R12: 22k; R_0603_1608Metric; LCSC C31850
R10: 43k; R_0603_1608Metric; LCSC C23172
R13: 30k 1%; R_0603_1608Metric; LCSC C22984
R14: 10k; R_0603_1608Metric; LCSC C25804
TP1: VBUS_A; TestPoint_Pad_D1.5mm
TP2: VBUS_B; TestPoint_Pad_D1.5mm
TP3: +5V; TestPoint_Pad_D1.5mm
TP4: +5V_LCD; TestPoint_Pad_D1.5mm
TP5: +3V3; TestPoint_Pad_D1.5mm
TP6: PWR_ST; TestPoint_Pad_D1.5mm
TP7: GND; TestPoint_Pad_D1.5mm
U1, U2: USBLC6-2SC6; SOT-23-6; LCSC C7519
U3: TPS2121RUX; Texas_RUX_VQFN-HR-12_2.5x2mm_P0.5mm; MPN TPS2121RUXR; LCSC C485916
U4: TPS22965DSG; Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; MPN TPS22965DSGR; LCSC C122837
U5: AP2127N-3.3; SOT-23-3; LCSC C176954

Connections:
+3V3: C11.1, R14.1, TP5.1 (1_1), U5.2 (VO); also elsewhere on the board
+5V: C4.1, C5.1, C6.1, C7.1, C10.1, TP3.1 (1_1), U1.5 (VBUS), U2.5 (VBUS), U3.1 (OUT), U3.8 (OUT), U4.1 (VIN), U4.2 (VIN), U4.4 (VBIAS), U5.3 (VI); also elsewhere on the board
+5V_LCD: C9.1, TP4.1 (1_1), U4.7 (VOUT), U4.8 (VOUT); also elsewhere on the board
CC1_A: J2.A5 (CC1), R3.1; also elsewhere on the board
CC1_B: J1.A5 (CC1), R1.1; also elsewhere on the board
CC2_A: J2.B5 (CC2), R4.1; also elsewhere on the board
CC2_B: J1.B5 (CC2), R2.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), R1.2, R2.2, R3.2, R4.2, R6.2, R8.2, R10.2, R12.2, R13.2, R15.2, TP7.1 (1_1), U1.2 (GND), U2.2 (GND), U3.12 (GND), U4.5 (GND), U4.9 (GND), U5.1 (GND); also elsewhere on the board
LCD_EN: R15.1, U4.3 (ON); also elsewhere on the board
unnamed: R9.2, R10.1, U3.3 (CP2)
unnamed: R13.1, U3.10 (ILM)
unnamed: R7.2, R8.1, U3.5 (OV1)
unnamed: R11.2, R12.1, U3.4 (OV2)
unnamed: R5.2, R6.1, U3.6 (PR1)
unnamed: C3.1, U3.11 (SS)
unnamed: C8.1, U4.6 (CT)
PWR_ST: R14.2, TP6.1 (1_1), U3.9 (ST); also elsewhere on the board
USB_A_D+: J2.A6 (D+), J2.B6 (D+), U2.1 (I/O1), U2.6 (I/O1); also elsewhere on the board
USB_A_D-: J2.A7 (D-), J2.B7 (D-), U2.3 (I/O2), U2.4 (I/O2); also elsewhere on the board
USB_B_D+: J1.A6 (D+), J1.B6 (D+), U1.1 (I/O1), U1.6 (I/O1); also elsewhere on the board
USB_B_D-: J1.A7 (D-), J1.B7 (D-), U1.3 (I/O2), U1.4 (I/O2); also elsewhere on the board
VBUS_A: C2.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R9.1, R11.1, TP1.1 (1_1), U3.2 (IN2)
VBUS_B: C1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R5.1, R7.1, TP2.1 (1_1), U3.7 (IN1)

Notes on the sheet:
常時 ON 3.3V
Port A
USB-C ×2 から +5V を作る。Port B（IN1）を優先し、TPS2121 が自動で切り替える（ST が High なら B、Low なら A から給電）。 CC の 5.1 kΩ でデバイスとして 5 V を受ける。CC の電圧は RP2040 の ADC で読む（rp2040 シートの R107〜R110）。 +3V3 は常時 ON（RP2040 と RTC 用）。+5V_LCD は RP2040 の LCD_EN で ON / OFF する。 詳細：docs/schematic/power.md
LCD 電源 TPS22965
テストパッド
電源切り替え TPS2121
Port B（IN1 優先）

Parts:
C201, C205: 10u; C_0603_1608Metric; LCSC C96446
C202, C203, C204: 100n; C_0603_1608Metric; LCSC C14663
C206: 0.1F 5.5V; CP_EDLC_10x5mm_P7.50mm_Horizontal; MPN CHP5R5L104R-TW
C207, C208: 1u; C_0603_1608Metric; LCSC C15849
D201, D202: B5819W; D_SOD-123; LCSC C8598
J201: microSD; microSD_HRO_TF-01A; LCSC C91145
JP201: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q201, Q202: 2N7002; SOT-23; LCSC C8545
R201, R210: 10k; R_0603_1608Metric; LCSC C25804
R202: 100k; R_0603_1608Metric; LCSC C25803
R208, R209: 4.7k; R_0603_1608Metric; LCSC C23162
R211: 100; R_1206_3216Metric; LCSC C17901
TP201: +3V3_CM0; TestPoint_Pad_D1.5mm
TP202: +1V8_CM0; TestPoint_Pad_D1.5mm
TP203: CM0_RUN_PG; TestPoint_Pad_D1.5mm
TP204: GLOBAL_EN; TestPoint_Pad_D1.5mm
TP205: NRPI_BOOT; TestPoint_Pad_D1.5mm
TP206: CM0_TXD; TestPoint_Pad_D1.5mm
TP207: CM0_RXD; TestPoint_Pad_D1.5mm
TP208: CM0_ACT; TestPoint_Pad_D1.5mm
TP209: WIFI_ON; TestPoint_Pad_D1.5mm
TP210: BT_ON; TestPoint_Pad_D1.5mm
U201: CM0100000; RaspberryPi_CM0_Castellated; MPN CM0100000
U202: SN74LVC1G125DBV; SOT-23-5; LCSC C23654
U203: AP2127K-3.3; SOT-23-5; LCSC C156285
U204: APX809S05-31SA-7; SOT-23; LCSC C2067622

Connections:
+1V8_CM0: TP202.1 (1_1), U201.64 (CM0_1.8V), U201.65 (CM0_1.8V); also elsewhere on the board
+3V3: R201.1; also elsewhere on the board
+3V3_CM0: C203.1, JP201.1 (A), R208.1, R209.1, R210.1, TP201.1 (1_1), U201.41 (CM0_3.3V), U201.119 (CM0_3.3V), U201.120 (GPIO_VREF), U201.122 (SD_VREF), U202.5 (VCC); also elsewhere on the board
+3V3_SD: C204.1, C205.1, C208.1, J201.4 (VDD), JP201.2 (B), U203.5 (VOUT)
+5V: C201.1, C202.1, D201.2 (A), U201.67 (5V), U201.68 (5V); also elsewhere on the board
/CM0 Sheet/BT_ON: TP210.1 (1_1), U201.117 (BT_ON)
/CM0 Sheet/CM0_ACT: TP208.1 (1_1), U201.118 (LED_nACT)
/CM0 Sheet/CM0_RXD: TP207.1 (1_1), U201.108 (GPIO15), U202.4
/CM0 Sheet/GLOBAL_EN: Q201.3 (D), TP204.1 (1_1), U201.62 (GLOBAL_EN)
/CM0 Sheet/NRPI_BOOT: Q202.3 (D), TP205.1 (1_1), U201.121 (nRPI_BOOT)
/CM0 Sheet/SD_CLK: J201.5 (CLK), U201.127 (SD_CLK)
/CM0 Sheet/SD_CMD: J201.3 (CMD), U201.128 (SD_CMD)
/CM0 Sheet/SD_DAT0: J201.7 (DAT0), U201.125 (SD_DAT0)
/CM0 Sheet/SD_DAT1: J201.8 (DAT1), U201.124 (SD_DAT1)
/CM0 Sheet/SD_DAT2: J201.1 (DAT2), U201.131 (SD_DAT2)
/CM0 Sheet/SD_DAT3: J201.2 (DAT3/CD), U201.130 (SD_DAT3)
/CM0 Sheet/SD_EN: U203.3 (EN), U204.2 (~RESET)
/CM0 Sheet/SD_HOLD: C206.1, D202.2 (A), R211.2
/CM0 Sheet/SD_VIN: C207.1, D201.1 (K), D202.1 (K), R211.1, U203.1 (VIN), U204.3 (V_{DD})
/CM0 Sheet/WIFI_ON: TP209.1 (1_1), U201.116 (WiFi_ON)
BOOT_EN: Q202.1 (G), R202.1; also elsewhere on the board
CM0_HALT: U201.76 (GPIO26); also elsewhere on the board
CM0_PWROFF: Q201.1 (G), R201.2; also elsewhere on the board
CM0_RUN_PG: TP203.1 (1_1), U201.61 (RUN_PG); also elsewhere on the board
CM0_TXD: TP206.1 (1_1), U201.110 (GPIO14); also elsewhere on the board
CODEC_RST: U201.102 (GPIO22); also elsewhere on the board
DSI_CK_N: U201.9 (DSI_CK_N); also elsewhere on the board
DSI_CK_P: U201.8 (DSI_CK_P); also elsewhere on the board
DSI_D0_N: U201.15 (DSI_D0_N); also elsewhere on the board
DSI_D0_P: U201.14 (DSI_D0_P); also elsewhere on the board
DSI_D1_N: U201.12 (DSI_D1_N); also elsewhere on the board
DSI_D1_P: U201.11 (DSI_D1_P); also elsewhere on the board
DSI_D2_N: U201.6 (DSI_D2_N); also elsewhere on the board
DSI_D2_P: U201.5 (DSI_D2_P); also elsewhere on the board
DSI_D3_N: U201.3 (DSI_D3_N); also elsewhere on the board
DSI_D3_P: U201.2 (DSI_D3_P); also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, J201.6 (VSS), J201.SH (SHIELD), Q201.2 (S), Q202.2 (S), R202.2, U201.1 (GND), U201.4 (GND), U201.7 (GND), U201.10 (GND), U201.13 (GND), U201.16 (GND), U201.21 (GND), U201.24 (GND), U201.27 (GND), U201.30 (GND), U201.33 (GND), U201.34 (GND), U201.37 (GND), U201.40 (GND), U201.45 (GND), U201.48 (GND), U201.51 (GND), U201.54 (GND), U201.57 (GND), U201.60 (GND), U201.63 (GND), U201.66 (GND), U201.69 (GND), U201.72 (GND), U201.75 (GND), U201.78 (GND), U201.81 (GND), U201.84 (GND), U201.87 (GND), U201.90 (GND), U201.93 (GND), U201.96 (GND), U201.99 (GND), U201.100 (GND), U201.103 (GND), U201.106 (GND), U201.109 (GND), U201.112 (GND), U201.115 (GND), U201.123 (GND), U201.126 (GND), U201.129 (GND), U201.132 (GND), U202.1, U202.3 (GND), U203.2 (GND), U204.1 (GND); also elsewhere on the board
HP_DET: U201.107 (GPIO17); also elsewhere on the board
I2C1_SCL: U201.113 (GPIO3); also elsewhere on the board
I2C1_SDA: U201.114 (GPIO2); also elsewhere on the board
I2C_DSI_SCL: U201.43 (SCL0); also elsewhere on the board
I2C_DSI_SDA: U201.42 (SDA0); also elsewhere on the board
I2S_BCLK: U201.105 (GPIO18); also elsewhere on the board
I2S_DOUT: U201.73 (GPIO21); also elsewhere on the board
I2S_LRCLK: U201.79 (GPIO19); also elsewhere on the board
KB_INT: R210.2, U201.94 (GPIO25); also elsewhere on the board
KB_SCL: R209.2, U201.98 (GPIO24); also elsewhere on the board
KB_SDA: R208.2, U201.101 (GPIO23); also elsewhere on the board
RP_TXD: U202.2; also elsewhere on the board
RTC_INT: U201.104 (GPIO27); also elsewhere on the board
USB_B_D+: U201.36 (USB_P); also elsewhere on the board
USB_B_D-: U201.35 (USB_N); also elsewhere on the board

Notes on the sheet:
+5V が切れると D201 が切り離し、C206 の電気で U203 が +3V3_SD を出し続ける。 カードは書き込み中の作業を終えられる（100 mA で約 0.5 秒）。 SD_VIN が 3.08 V を下回ると U204 が U203 を止め、電圧がだらだら下がらないよう、すぱっと切る。 C206・R211・D202 は外してもよい（持たないだけで動く）。 U203 を外すときは JP201 を閉じる（U203 を載せたまま閉じると、U203 と CM0 の 3.3V がぶつかる）。 電源を入れてから U204 が U203 を ON にするまで 240 ms 以上かかる。RP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
nRPI_BOOT（RP2040 から要求）
UART の受信バッファ（+3V3_CM0 で動作）
GLOBAL_EN（初期状態は OFF）
CM0：ディスプレイ / カメラ（DSI と I2C だけ使う）
SD カードの電源（電源が切れても 0.5 秒持たせる）
CM0：システム
CM0：GPIO
テストパッド
CM0：電源
CM0 が OFF（+3V3_CM0 = 0 V）のときに電流を流し込まないよう、RP2040 とつながる線のプルアップは +3V3_CM0 側に置き、 UART の受信は Ioff 付きのバッファ（U202）を通す。 GLOBAL_EN は CM0 の内部で 5 V にプルアップされているので、Q201 で Low に引く。初期状態は OFF。 SD の CMD / DAT0〜3 に外付けのプルアップはない（CM4IO と同じ。SoC の内部プルアップを使う）。 詳細：docs/schematic/cm0.md

Parts:
C501, C502, C503, C504, C505, C506, C507, C508, C509, C510, C511, C512, C513, C514, C515, C516, C517, C518, C519, C520, C521, C522, C523, C524, C525, C526, C527, C528, C529, C530, C531, C532, C533, C534, C535, C536, C537, C538, C539, C540, C541, C542, C544, C545: 100n; C_0603_1608Metric; LCSC C14663
C543: 10u; C_0603_1608Metric; LCSC C96446
D501, D502, D503, D504, D505, D506, D507, D508, D509, D510, D511, D512, D513, D514, D515, D516, D517, D518, D519, D520, D521, D522, D523, D524, D525, D526, D527, D528, D529, D530, D531, D532, D533, D534, D535, D536, D537, D538, D539, D540, D541, D542: 1N4148W; D_SOD-123; LCSC C81598
LED501, LED502, LED503, LED504, LED505, LED506, LED507, LED508, LED509, LED510, LED511, LED512, LED513, LED514, LED515, LED516, LED517, LED518, LED519, LED520, LED521, LED522, LED523, LED524, LED525, LED526, LED527, LED528, LED529, LED530, LED531, LED532, LED533, LED534, LED535, LED536, LED537, LED538, LED539, LED540, LED541, LED542: SK6812MINI-E; LED_SK6812MINI-E_3.2x2.8mm_P1.5mm_ReverseMount; LCSC C5149201
Q501: AO3401A; SOT-23; LCSC C15127
Q502: 2N7002; SOT-23; LCSC C8545
R501, R503: 100k; R_0603_1608Metric; LCSC C25803
R502: 10k; R_0603_1608Metric; LCSC C25804
R504: 330; R_0603_1608Metric; LCSC C23138
SW501: Esc; CPG135001S30_1U
SW502: Q; CPG135001S30_1U
SW503: W; CPG135001S30_1U
SW504: E; CPG135001S30_1U
SW505: R; CPG135001S30_1U
SW506: T; CPG135001S30_1U
SW507: Y; CPG135001S30_1U
SW508: U; CPG135001S30_1U
SW509: I; CPG135001S30_1U
SW510: O; CPG135001S30_1U
SW511: P; CPG135001S30_1U
SW512: Bksp; CPG135001S30_1U
SW513: Tab; CPG135001S30_1.25U
SW514: A; CPG135001S30_1U
SW515: S; CPG135001S30_1U
SW516: D; CPG135001S30_1U
SW517: F; CPG135001S30_1U
SW518: G; CPG135001S30_1U
SW519: H; CPG135001S30_1U
SW520: J; CPG135001S30_1U
SW521: K; CPG135001S30_1U
SW522: L; CPG135001S30_1U
SW523: Enter; CPG135001S30_1.75U
SW524: LShift; CPG135001S30_1.75U
SW525: Z; CPG135001S30_1U
SW526: X; CPG135001S30_1U
SW527: C; CPG135001S30_1U
SW528: V; CPG135001S30_1U
SW529: B; CPG135001S30_1U
SW530: N; CPG135001S30_1U
SW531: M; CPG135001S30_1U
SW532: <; CPG135001S30_1U
SW533: >; CPG135001S30_1U
SW534: ?; CPG135001S30_1.25U
SW535: LCtrl; CPG135001S30_1.25U
SW536: LGui; CPG135001S30_1U
SW537: LAlt; CPG135001S30_1.25U
SW538: Space; CPG135001S30_2.75U
SW539: Space; CPG135001S30_2.25U
SW540: RAlt; CPG135001S30_1.25U
SW541: RGui; CPG135001S30_1U
SW542: RCtrl; CPG135001S30_1.25U
U501: 74AHCT1G125; SOT-23-5; MPN SN74AHCT1G125DBVR; LCSC C7484

Connections:
+5V: C545.1, Q501.2 (S), R501.1; also elsewhere on the board
+5V_LED: C501.1, C502.1, C503.1, C504.1, C505.1, C506.1, C507.1, C508.1, C509.1, C510.1, C511.1, C512.1, C513.1, C514.1, C515.1, C516.1, C517.1, C518.1, C519.1, C520.1, C521.1, C522.1, C523.1, C524.1, C525.1, C526.1, C527.1, C528.1, C529.1, C530.1, C531.1, C532.1, C533.1, C534.1, C535.1, C536.1, C537.1, C538.1, C539.1, C540.1, C541.1, C542.1, C543.1, C544.1, LED501.3 (VDD), LED502.3 (VDD), LED503.3 (VDD), LED504.3 (VDD), LED505.3 (VDD), LED506.3 (VDD), LED507.3 (VDD), LED508.3 (VDD), LED509.3 (VDD), LED510.3 (VDD), LED511.3 (VDD), LED512.3 (VDD), LED513.3 (VDD), LED514.3 (VDD), LED515.3 (VDD), LED516.3 (VDD), LED517.3 (VDD), LED518.3 (VDD), LED519.3 (VDD), LED520.3 (VDD), LED521.3 (VDD), LED522.3 (VDD), LED523.3 (VDD), LED524.3 (VDD), LED525.3 (VDD), LED526.3 (VDD), LED527.3 (VDD), LED528.3 (VDD), LED529.3 (VDD), LED530.3 (VDD), LED531.3 (VDD), LED532.3 (VDD), LED533.3 (VDD), LED534.3 (VDD), LED535.3 (VDD), LED536.3 (VDD), LED537.3 (VDD), LED538.3 (VDD), LED539.3 (VDD), LED540.3 (VDD), LED541.3 (VDD), LED542.3 (VDD), Q501.3 (D), U501.5 (VCC)
/Keymatrix Sheet/RGB_D0: LED501.2 (DIN), R504.2
COL0: SW501.1, SW512.1, SW513.1, SW524.1, SW535.1, SW541.1, SW542.1; also elsewhere on the board
COL1: SW502.1, SW511.1, SW514.1, SW523.1, SW525.1, SW534.1, SW536.1; also elsewhere on the board
COL2: SW503.1, SW510.1, SW515.1, SW522.1, SW526.1, SW533.1, SW537.1; also elsewhere on the board
COL3: SW504.1, SW509.1, SW516.1, SW521.1, SW527.1, SW532.1, SW540.1; also elsewhere on the board
COL4: SW505.1, SW508.1, SW517.1, SW520.1, SW528.1, SW531.1, SW538.1; also elsewhere on the board
COL5: SW506.1, SW507.1, SW518.1, SW519.1, SW529.1, SW530.1, SW539.1; also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, C517.2, C518.2, C519.2, C520.2, C521.2, C522.2, C523.2, C524.2, C525.2, C526.2, C527.2, C528.2, C529.2, C530.2, C531.2, C532.2, C533.2, C534.2, C535.2, C536.2, C537.2, C538.2, C539.2, C540.2, C541.2, C542.2, C543.2, C544.2, LED501.1 (VSS), LED502.1 (VSS), LED503.1 (VSS), LED504.1 (VSS), LED505.1 (VSS), LED506.1 (VSS), LED507.1 (VSS), LED508.1 (VSS), LED509.1 (VSS), LED510.1 (VSS), LED511.1 (VSS), LED512.1 (VSS), LED513.1 (VSS), LED514.1 (VSS), LED515.1 (VSS), LED516.1 (VSS), LED517.1 (VSS), LED518.1 (VSS), LED519.1 (VSS), LED520.1 (VSS), LED521.1 (VSS), LED522.1 (VSS), LED523.1 (VSS), LED524.1 (VSS), LED525.1 (VSS), LED526.1 (VSS), LED527.1 (VSS), LED528.1 (VSS), LED529.1 (VSS), LED530.1 (VSS), LED531.1 (VSS), LED532.1 (VSS), LED533.1 (VSS), LED534.1 (VSS), LED535.1 (VSS), LED536.1 (VSS), LED537.1 (VSS), LED538.1 (VSS), LED539.1 (VSS), LED540.1 (VSS), LED541.1 (VSS), LED542.1 (VSS), Q502.2 (S), R503.2, U501.1, U501.3 (GND); also elsewhere on the board
unnamed: D501.2 (A), SW501.2
unnamed: D502.2 (A), SW502.2
unnamed: D503.2 (A), SW503.2
unnamed: D504.2 (A), SW504.2
unnamed: D505.2 (A), SW505.2
unnamed: D506.2 (A), SW506.2
unnamed: D507.2 (A), SW507.2
unnamed: D508.2 (A), SW508.2
unnamed: D509.2 (A), SW509.2
unnamed: D510.2 (A), SW510.2
unnamed: D511.2 (A), SW511.2
unnamed: D512.2 (A), SW512.2
unnamed: D513.2 (A), SW513.2
unnamed: D514.2 (A), SW514.2
unnamed: D515.2 (A), SW515.2
unnamed: D516.2 (A), SW516.2
unnamed: D517.2 (A), SW517.2
unnamed: D518.2 (A), SW518.2
unnamed: D519.2 (A), SW519.2
unnamed: D520.2 (A), SW520.2
unnamed: D521.2 (A), SW521.2
unnamed: D522.2 (A), SW522.2
unnamed: D523.2 (A), SW523.2
unnamed: D524.2 (A), SW524.2
unnamed: D525.2 (A), SW525.2
unnamed: D526.2 (A), SW526.2
unnamed: D527.2 (A), SW527.2
unnamed: D528.2 (A), SW528.2
unnamed: D529.2 (A), SW529.2
unnamed: D530.2 (A), SW530.2
unnamed: D531.2 (A), SW531.2
unnamed: D532.2 (A), SW532.2
unnamed: D533.2 (A), SW533.2
unnamed: D534.2 (A), SW534.2
unnamed: D535.2 (A), SW535.2
unnamed: D536.2 (A), SW536.2
unnamed: D537.2 (A), SW537.2
unnamed: D538.2 (A), SW538.2
unnamed: D539.2 (A), SW539.2
unnamed: D540.2 (A), SW540.2
unnamed: D541.2 (A), SW541.2
unnamed: D542.2 (A), SW542.2
unnamed: LED501.4 (DOUT), LED502.2 (DIN)
unnamed: LED502.4 (DOUT), LED503.2 (DIN)
unnamed: LED503.4 (DOUT), LED504.2 (DIN)
unnamed: LED504.4 (DOUT), LED505.2 (DIN)
unnamed: LED505.4 (DOUT), LED506.2 (DIN)
unnamed: LED506.4 (DOUT), LED507.2 (DIN)
unnamed: LED507.4 (DOUT), LED508.2 (DIN)
unnamed: LED508.4 (DOUT), LED509.2 (DIN)
unnamed: LED509.4 (DOUT), LED510.2 (DIN)
unnamed: LED510.4 (DOUT), LED511.2 (DIN)
unnamed: LED511.4 (DOUT), LED512.2 (DIN)
unnamed: LED512.4 (DOUT), LED523.2 (DIN)
unnamed: LED513.2 (DIN), LED514.4 (DOUT)
unnamed: LED513.4 (DOUT), LED524.2 (DIN)
unnamed: LED514.2 (DIN), LED515.4 (DOUT)
unnamed: LED515.2 (DIN), LED516.4 (DOUT)
unnamed: LED516.2 (DIN), LED517.4 (DOUT)
unnamed: LED517.2 (DIN), LED518.4 (DOUT)
unnamed: LED518.2 (DIN), LED519.4 (DOUT)
unnamed: LED519.2 (DIN), LED520.4 (DOUT)
unnamed: LED520.2 (DIN), LED521.4 (DOUT)
unnamed: LED521.2 (DIN), LED522.4 (DOUT)
unnamed: LED522.2 (DIN), LED523.4 (DOUT)
unnamed: LED524.4 (DOUT), LED525.2 (DIN)
unnamed: LED525.4 (DOUT), LED526.2 (DIN)
unnamed: LED526.4 (DOUT), LED527.2 (DIN)
unnamed: LED527.4 (DOUT), LED528.2 (DIN)
unnamed: LED528.4 (DOUT), LED529.2 (DIN)
unnamed: LED529.4 (DOUT), LED530.2 (DIN)
unnamed: LED530.4 (DOUT), LED531.2 (DIN)
unnamed: LED531.4 (DOUT), LED532.2 (DIN)
unnamed: LED532.4 (DOUT), LED533.2 (DIN)
unnamed: LED533.4 (DOUT), LED534.2 (DIN)
unnamed: LED534.4 (DOUT), LED542.2 (DIN)
unnamed: LED535.2 (DIN), LED536.4 (DOUT)
unnamed: LED536.2 (DIN), LED537.4 (DOUT)
unnamed: LED537.2 (DIN), LED538.4 (DOUT)
unnamed: LED538.2 (DIN), LED539.4 (DOUT)
unnamed: LED539.2 (DIN), LED540.4 (DOUT)
unnamed: LED540.2 (DIN), LED541.4 (DOUT)
unnamed: LED541.2 (DIN), LED542.4 (DOUT)
unnamed: C545.2, Q501.1 (G), R501.2, R502.2
unnamed: Q502.3 (D), R502.1
unnamed: R504.1, U501.4
RGB_DATA: U501.2; also elsewhere on the board
RGB_EN: Q502.1 (G), R503.1; also elsewhere on the board
ROW0: D501.1 (K), D502.1 (K), D503.1 (K), D504.1 (K), D505.1 (K), D506.1 (K); also elsewhere on the board
ROW1: D507.1 (K), D508.1 (K), D509.1 (K), D510.1 (K), D511.1 (K), D512.1 (K); also elsewhere on the board
ROW2: D513.1 (K), D514.1 (K), D515.1 (K), D516.1 (K), D517.1 (K), D518.1 (K); also elsewhere on the board
ROW3: D519.1 (K), D520.1 (K), D521.1 (K), D522.1 (K), D523.1 (K), D542.1 (K); also elsewhere on the board
ROW4: D524.1 (K), D525.1 (K), D526.1 (K), D527.1 (K), D528.1 (K), D529.1 (K); also elsewhere on the board
ROW5: D530.1 (K), D531.1 (K), D532.1 (K), D533.1 (K), D534.1 (K), D541.1 (K); also elsewhere on the board
ROW6: D535.1 (K), D536.1 (K), D537.1 (K), D538.1 (K), D539.1 (K), D540.1 (K); also elsewhere on the board

Notes on the sheet:
データ（RGB_D0）が流れる順に並べている。基板上の並びは hardware/layout/README.md。LED501〜LED542 はすべて SK6812MINI-E。
キーの RGB：LED の電源の ON / OFF とデータのバッファ
LED のパスコン（各 LED に 100 nF ×1。基板では各 LED の隣に置く）
キーの RGB（SK6812MINI-E ×42）。詳細は docs/schematic/keymatrix.md
キーマトリクス（7 行 × 6 列、COL2ROW。対応は hardware/layout/README.md）
