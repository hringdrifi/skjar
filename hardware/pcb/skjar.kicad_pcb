# Repository hringdrifi/skjar (continued)

## KiCad design hardware/pcb/skjar.kicad_pcb (continued)

Parts:
C101, C102, C103, C104, C105, C106, C107, C111, C112, C115: 100n; C_0603_1608Metric; LCSC C14663
C109, C110: 1u; C_0603_1608Metric; LCSC C15849
C113, C114: 27p; C_0603_1608Metric; LCSC C107045
R101, R102, R107, R108, R109, R110: 1k; R_0603_1608Metric; LCSC C21190
R103: 10k; R_0603_1608Metric; LCSC C25804
R105, R106: 27; R_0603_1608Metric; LCSC C25190
SW101: BOOTSEL; SW_Push_1P1T_XKB_TS-1187A; LCSC C318884
TP101: +3V3; TestPoint_Pad_D1.5mm
TP102: GND; TestPoint_Pad_D1.5mm
TP103: RUN; TestPoint_Pad_D1.5mm
TP104: SWCLK; TestPoint_Pad_D1.5mm
TP105: SWDIO; TestPoint_Pad_D1.5mm
TP106: GPIO24; TestPoint_Pad_D1.5mm
TP107: GPIO25; TestPoint_Pad_D1.5mm
TP108: KB_INT; TestPoint_Pad_D1.5mm
U101: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm; LCSC C2040
U102: W25Q128JVPIQ; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm; LCSC C190862
Y101: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN XXHBBCNANF-12.000000MHZ; LCSC C521581

Connections:
+1V1: C110.1, C111.1, C112.1, U101.23 (DVDD), U101.45 (VREG_VOUT), U101.50 (DVDD)
+3V3: C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C109.1, C115.1, R103.1, TP101.1 (1_1), U101.1 (IOVDD), U101.10 (IOVDD), U101.22 (IOVDD), U101.33 (IOVDD), U101.42 (IOVDD), U101.43 (ADC_AVDD), U101.44 (VREG_VIN), U101.48 (USB_VDD), U101.49 (IOVDD), U102.8 (VCC); also elsewhere on the board
/RP2040 Sheet/QSPI_SCLK: U101.52 (QSPI_SCLK), U102.6 (CLK)
/RP2040 Sheet/QSPI_SD0: U101.53 (QSPI_SD0), U102.5 (DI/IO_{0})
/RP2040 Sheet/QSPI_SD1: U101.55 (QSPI_SD1), U102.2 (DO/IO_{1})
/RP2040 Sheet/QSPI_SD2: U101.54 (QSPI_SD2), U102.3 (~WP/IO_{2})
/RP2040 Sheet/QSPI_SD3: U101.51 (QSPI_SD3), U102.7 (~HOLD/~RESET/IO_{3})
/RP2040 Sheet/RUN: R103.2, TP103.1 (1_1), U101.26 (RUN)
/RP2040 Sheet/SWCLK: TP104.1 (1_1), U101.24 (SWCLK)
/RP2040 Sheet/SWDIO: TP105.1 (1_1), U101.25 (SWDIO)
/RP2040 Sheet/USB_DN: R106.1, U101.46 (USB_DM)
/RP2040 Sheet/USB_DP: R105.1, U101.47 (USB_DP)
/RP2040 Sheet/~QSPI_SS: SW101.1, U101.56 (~QSPI_SS), U102.1 (~CS)
BOOT_EN: U101.35 (GPIO23); also elsewhere on the board
CC1_A: R107.1; also elsewhere on the board
CC1_B: R109.1; also elsewhere on the board
CC2_A: R108.1; also elsewhere on the board
CC2_B: R110.1; also elsewhere on the board
CM0_HALT: U101.34 (GPIO22); also elsewhere on the board
CM0_PWROFF: U101.18 (GPIO15); also elsewhere on the board
CM0_RUN_PG: U101.32 (GPIO21); also elsewhere on the board
CM0_TXD: U101.28 (GPIO17); also elsewhere on the board
COL0: U101.6 (GPIO4); also elsewhere on the board
COL1: U101.7 (GPIO5); also elsewhere on the board
COL2: U101.5 (GPIO3); also elsewhere on the board
COL3: U101.4 (GPIO2); also elsewhere on the board
COL4: U101.3 (GPIO1); also elsewhere on the board
COL5: U101.2 (GPIO0); also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, R102.2, TP102.1 (1_1), U101.19 (TESTEN), U101.57 (GND), U102.4 (GND), U102.9 (GND), Y101.2 (G), Y101.4 (G); also elsewhere on the board
KB_INT: TP108.1 (1_1), U101.16 (GPIO13); also elsewhere on the board
KB_SCL: TP107.1 (1_1), U101.37 (GPIO25); also elsewhere on the board
KB_SDA: TP106.1 (1_1), U101.36 (GPIO24); also elsewhere on the board
LCD_EN: U101.29 (GPIO18); also elsewhere on the board
unnamed: C114.1, R101.1, Y101.3
unnamed: R102.1, SW101.2
unnamed: R107.2, U101.38 (GPIO26/ADC0)
unnamed: R108.2, U101.39 (GPIO27/ADC1)
unnamed: R109.2, U101.40 (GPIO28/ADC2)
unnamed: R110.2, U101.41 (GPIO29/ADC3)
unnamed: C113.1, U101.20 (XIN), Y101.1
unnamed: R101.2, U101.21 (XOUT)
PWR_ST: U101.30 (GPIO19); also elsewhere on the board
RGB_DATA: U101.17 (GPIO14); also elsewhere on the board
RGB_EN: U101.31 (GPIO20); also elsewhere on the board
ROW0: U101.13 (GPIO10); also elsewhere on the board
ROW1: U101.8 (GPIO6); also elsewhere on the board
ROW2: U101.14 (GPIO11); also elsewhere on the board
ROW3: U101.9 (GPIO7); also elsewhere on the board
ROW4: U101.15 (GPIO12); also elsewhere on the board
ROW5: U101.11 (GPIO8); also elsewhere on the board
ROW6: U101.12 (GPIO9); also elsewhere on the board
RP_TXD: U101.27 (GPIO16); also elsewhere on the board
USB_A_D+: R105.2; also elsewhere on the board
USB_A_D-: R106.2; also elsewhere on the board

Notes on the sheet:
テストパッド
キーボードのコントローラ。キーマトリクスと RGB を受け持ち、PC へは Port A の USB HID、CM0 へは I²C（KB_SDA / KB_SCL / KB_INT）で送る。 CM0 の電源（CM0_PWROFF → GLOBAL_EN）と起動モード（BOOT_EN → nRPI_BOOT）も RP2040 が操作する。 CC1_A〜CC2_B は 1 kΩ を通して ADC へ（PC がつながっているかの判定）。 ファームは BOOTSEL を押しながら Port A から UF2 で書き込む。SWD はテストパッドだけ。 詳細：docs/schematic/rp2040.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
BOOTSEL（UF2）
QSPI フラッシュ

Parts:
C301: 100n; C_0603_1608Metric; LCSC C14663
J301: DSI FPC 22P 0.5mm; Hirose_FH12-22S-0.5SH_1x22-1MP_P0.50mm_Horizontal; LCSC C597981
J302: LCD 5V (5V/5V/GND); PinHeader_1x03_P2.54mm_Horizontal

Connections:
+3V3_CM0: C301.1, J301.1; also elsewhere on the board
+5V_LCD: J302.1, J302.2; also elsewhere on the board
DSI_CK_N: J301.15; also elsewhere on the board
DSI_CK_P: J301.14; also elsewhere on the board
DSI_D0_N: J301.21; also elsewhere on the board
DSI_D0_P: J301.20; also elsewhere on the board
DSI_D1_N: J301.18; also elsewhere on the board
DSI_D1_P: J301.17; also elsewhere on the board
DSI_D2_N: J301.12; also elsewhere on the board
DSI_D2_P: J301.11; also elsewhere on the board
DSI_D3_N: J301.9; also elsewhere on the board
DSI_D3_P: J301.8; also elsewhere on the board
GND: C301.2, J301.4, J301.7, J301.10, J301.13, J301.16, J301.19, J301.22, J302.3; also elsewhere on the board
I2C_DSI_SCL: J301.3; also elsewhere on the board
I2C_DSI_SDA: J301.2; also elsewhere on the board

Notes on the sheet:
LCD の電源（ライトアングル 1x3、5V / 5V / GND）
DSI（22 ピン FPC、Raspberry Pi 5 と同じピン配置）
J301 のピン番号は Raspberry Pi 5 / CM4 と同じ順。付属の FFC（両端で接点の向きが逆）で、基板の n 番がパネルの 23 − n 番につながる。 片面接点（上接点）の Hirose FH12A を使い、逆向きには接点が当たらないようにしている。 詳細：docs/schematic/display.md

Parts:
BT401: CR2032; BatteryHolder_MYOUNG_MY-2032-08; LCSC C964831
C401, C403, C404, C406, C407, C409, C411, C414: 100n; C_0603_1608Metric; LCSC C14663
C402: 22u; C_0805_2012Metric; LCSC C45783
C405, C408, C410: 10u; C_0603_1608Metric; LCSC C96446
C412, C413: 220u; CP_Elec_6.3x7.7; LCSC C970695
D401: BAT54C; SOT-23
FB401: 600R; L_0805_2012Metric; LCSC C1017
J401: Speaker; Molex_PicoBlade_53261-0271_1x02-1MP_P1.25mm_Horizontal; LCSC C177225
J402: PJ-320D-4A; Jack_3.5mm_KoreanHropartsElec_PJ-320D-4A_Horizontal; LCSC C95562
R401, R404, R405: 10k; R_0603_1608Metric; LCSC C25804
R403, R406: 100k; R_0603_1608Metric; LCSC C25803
U401: PCF8563T; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C7440
U402: TLV320DAC3100; Texas_RHB0032E_VQFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm; MPN TLV320DAC3100IRHBR; LCSC C179677
Y401: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm; LCSC C479190
Y402: 12MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN OT2EL89CJI-111YLC-12M; LCSC C5280582

Connections:
+1V8_CM0: C408.1, C409.1, U402.3 (DVDD); also elsewhere on the board
+3V3: D401.1; also elsewhere on the board
+3V3_CM0: C410.1, C411.1, C414.1, FB401.1, R401.1, R403.1, U402.2 (IOVDD), Y402.1 (EN), Y402.4 (Vdd); also elsewhere on the board
+5V: C402.1, C403.1, C404.1, U402.21 (SPKVDD), U402.24 (SPKVDD); also elsewhere on the board
/Peripherals Sheet/HPL_OUT: C412.1, U402.27 (HPL)
/Peripherals Sheet/HPR_OUT: C413.1, U402.30 (HPR)
/Peripherals Sheet/JACK_L: C412.2, J402.T, R404.1
/Peripherals Sheet/JACK_R: C413.2, J402.R1, R405.1
AVDD_CODEC: C405.1, C406.1, C407.1, FB401.2, U402.17 (AVDD), U402.28 (HPVDD)
CODEC_RST: R406.1, U402.31 (~RESET); also elsewhere on the board
GND: BT401.2 (-), C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C414.2, J402.R2, R404.2, R405.2, R406.2, U401.4 (VSS), U402.1 (IOVSS), U402.16 (AVSS), U402.18 (DVSS), U402.20 (SPKVSS), U402.25 (SPKVSS), U402.29 (HPVSS), U402.33 (PAD), Y402.2 (GND); also elsewhere on the board
HP_DET: J402.S, R403.2; also elsewhere on the board
I2C1_SCL: U401.6 (SCL), U402.10 (SCL); also elsewhere on the board
I2C1_SDA: U401.5 (SDA), U402.9 (SDA); also elsewhere on the board
I2S_BCLK: U402.7 (BCLK); also elsewhere on the board
I2S_DOUT: U402.5 (DIN); also elsewhere on the board
I2S_LRCLK: U402.6 (WCLK); also elsewhere on the board
unnamed: J401.1, U402.22 (SPKP), U402.26 (SPKP)
unnamed: J401.2, U402.19 (SPKM), U402.23 (SPKM)
unnamed: U401.1 (OSCI), Y401.1
unnamed: U401.2 (OSCO), Y401.2
unnamed: U402.8 (MCLK), Y402.3 (OUT)
RTC_INT: R401.2, U401.3 (~INT); also elsewhere on the board
VBAT: BT401.1 (+), D401.2
VDD_RTC: C401.1, D401.3, U401.8 (VDD)

Notes on the sheet:
音声（TLV320DAC3100）
RTC は +3V3（常時 ON）と CR2032 の高い方から BAT54C で給電する。CM0 が OFF でも時刻を保つ。 I2C1 のプルアップは CM0 の内部（1.8 kΩ）を使う。 音声 IC は SPKVDD だけ +5V、ほかは CM0 の 3.3 V / 1.8 V から取り、CM0 と一緒に ON / OFF する（データシートの推奨順序に合う）。 詳細：docs/schematic/peripherals.md
RTC（PCF8563T + CR2032）

Board: 2 copper layers, 228.6 x 143.3 mm, 325 parts (318 on the bottom side), 205 nets.

Other parts of the board:
CASE1: SKJAR_Case
DISP1: Waveshare_8.8-DSI-TOUCH-A_Studs
DISP2: Waveshare_8.8inch_DSI_LCD_Check
H8, H9: MountingHole_M2_CaseBoss
STAB1: CPG1353G24D01_2.75U
STAB2: CPG1353G24D01_2.25U

## Code that names these connections

File firmware/rp2040/src/main.rs (part):

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))]
compile_error!("feature の `pico`、`xiao`、`skjar` は、どれか 1 つだけを選ぶ（`xiao` と `skjar` は --no-default-features と一緒に）");

// キー入力の I²C。SKJÁR は I2C0（GPIO24 / 25）。Pico と XIAO では GPIO24 / 25 が外に出ていないので
// I2C1（GPIO26 / 27。XIAO では D0 / D1）を使う。
#[cfg(feature = "skjar")]
type KbI2c = embassy_rp::peripherals::I2C0;
#[cfg(not(feature = "skjar"))]
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    // ログ（USB の仮想シリアル）
    spawner.spawn(usb_task(Driver::new(p.USB, Irqs)).unwrap());

    // KB_INT（GPIO13。XIAO では D2 の GPIO28）：Low で CM0 に知らせる。オープンドレインを真似る（hid_i2c 参照）。
    #[cfg(not(feature = "xiao"))]
    hid_i2c::init_int_pin(Flex::new(p.PIN_13));
    #[cfg(feature = "xiao")]
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    let i2c = I2cSlave::new(p.I2C1, p.PIN_27, p.PIN_26, Irqs, i2c_config);
    spawner.spawn(hid_i2c_task(i2c).unwrap());

    // CM0 との UART（UART0：GPIO16 TX → CM0 の GPIO15、GPIO17 RX ← CM0 の GPIO14。
    // XIAO では GPIO16 / 17 が基板の LED なので、D6 の GPIO0 TX と D7 の GPIO1 RX）。
    // TX は CM0 の 3.3V で動くバッファを通るので、CM0 が OFF でも電流は流れ込まない。
    // RX には内部のプルを付けない（embassy-rp の初期化はプルを有効にしない）。
    static UART_TX_BUF: StaticCell<[u8; 256]> = StaticCell::new();
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    rmk::state::set_usb_state(UsbState::Configured);
    spawner.spawn(report_bridge_task().unwrap());

    // キーの RGB（GPIO14 RGB_DATA を PIO0 で、GPIO20 RGB_EN は High で電源 ON。初めは OFF）。
    // Pico で試すときは、同じ GP14 / GP20 に WS2812 のテープ LED などをつなぐ
    let mut pio = Pio::new(p.PIO0, Irqs);
    let ws2812 = PioWs2812Program::new(&mut pio.common);
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    // RMK の COL2ROW は、列を High に駆動して行を読む（行はプルダウン）。
    #[cfg(not(feature = "xiao"))]
    let rows = [
        Input::new(p.PIN_10, Pull::Down), // ROW0
        Input::new(p.PIN_6, Pull::Down),  // ROW1
        Input::new(p.PIN_11, Pull::Down), // ROW2
        Input::new(p.PIN_7, Pull::Down),  // ROW3
        Input::new(p.PIN_12, Pull::Down), // ROW4
        Input::new(p.PIN_8, Pull::Down),  // ROW5
        Input::new(p.PIN_9, Pull::Down),  // ROW6
    ];
    #[cfg(not(feature = "xiao"))]
    let cols = [
        Output::new(p.PIN_4, Level::Low), // COL0
        Output::new(p.PIN_5, Level::Low), // COL1
        Output::new(p.PIN_3, Level::Low), // COL2
        Output::new(p.PIN_2, Level::Low), // COL3
        Output::new(p.PIN_1, Level::Low), // COL4
        Output::new(p.PIN_0, Level::Low), // COL5
    ];
    // XIAO：外に出ている 6 本を 3 行 × 3 列にして、ROW2・ROW4・ROW6 の 1・2・5 列目（9 キー）を試す。
    // 親指の段（ROW6）の 5 列目がレイヤー 2（押し続ける）なので、レイヤー 2 の音量キー（ROW2）と
    // USER キー（ROW4）も試せる。ほかの行と列は、外に出ていない（何もつながっていない）ピンにする。
    // 行はプルダウンなので押されることはない。GPIO11 / 12（基板の RGB LED の電源とデータ）と
    // 16 / 17 / 25（基板の LED）は避ける
    #[cfg(feature = "xiao")]
    let rows = [
        Input::new(p.PIN_10, Pull::Down), // ROW0  （出ていない）
        Input::new(p.PIN_8, Pull::Down),  // ROW1  （出ていない）
        Input::new(p.PIN_6, Pull::Down),  // ROW2  D4：A S G（レイヤー 2 で Mute、音量 −）
        Input::new(p.PIN_9, Pull::Down),  // ROW3  （出ていない）
        Input::new(p.PIN_7, Pull::Down),  // ROW4  D5：Z X B（レイヤー 2 で USER0、USER1）
        Input::new(p.PIN_13, Pull::Down), // ROW5  （出ていない）
        Input::new(p.PIN_29, Pull::Down), // ROW6  D3：LGui LAlt Space（押し続けるとレイヤー 2）
    ];
    #[cfg(feature = "xiao")]
    let cols = [
        Output::new(p.PIN_15, Level::Low), // COL0  （出ていない）
        Output::new(p.PIN_4, Level::Low),  // COL1  D9
        Output::new(p.PIN_3, Level::Low),  // COL2  D10
        Output::new(p.PIN_18, Level::Low), // COL3  （出ていない）
        Output::new(p.PIN_19, Level::Low), // COL4  （出ていない）
        Output::new(p.PIN_2, Level::Low),  // COL5  D8
    ];
    let mut matrix = Matrix::<_, _, _, MATRIX_ROW, COL, true>::new(rows, cols, DefaultDebouncer::new());

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
File software/os/overlays/skjar-audio-overlay.dts:

// SKJAR audio: TLV320DAC3100 on I2C1 (0x18) and I2S (GPIO18/19/21)
//
// Build and install (on the CM0):
//   dtc -@ -I dts -O dtb -o skjar-audio.dtbo skjar-audio-overlay.dts
//   sudo cp skjar-audio.dtbo /boot/firmware/overlays/
//
// config.txt:
//   dtparam=i2c_arm=on
//   dtparam=i2s=on
//   dtparam=audio=off
//   dtoverlay=skjar-audio
//
// A 12 MHz oscillator (Y402) drives MCLK and the codec is the I2S clock
// master; the Pi only receives BCLK and LRCLK. simple-audio-card calls
// set_sysclk() with clk_id 0 (MCLK), which is what this setup needs, so
// the stock tlv320aic31xx driver works as is. See README.md.
//
// GPIO17 (HP_DET) is low when a plug is inserted. GPIO22 is the codec
// reset (active low).

/dts-v1/;
/plugin/;

/ {
	compatible = "brcm,bcm2835";

	// I2S, codec drives BCLK and LRCLK
	fragment@0 {
		target = <&i2s_clk_consumer>;
		__overlay__ {
			status = "okay";
		};
	};

	// Fixed supplies (all always on)
	fragment@1 {
		target-path = "/";
		__overlay__ {
			vdd_5v_spk: skjar-audio-5v {
				compatible = "regulator-fixed";
				regulator-name = "skjar-spkvdd";
				regulator-min-microvolt = <5000000>;
				regulator-max-microvolt = <5000000>;
				regulator-always-on;
			};

			vdd_3v3_audio: skjar-audio-3v3 {
				compatible = "regulator-fixed";
				regulator-name = "skjar-avdd";
				regulator-min-microvolt = <3300000>;
				regulator-max-microvolt = <3300000>;
				regulator-always-on;
			};

			vdd_1v8_audio: skjar-audio-1v8 {
				compatible = "regulator-fixed";
				regulator-name = "skjar-dvdd";
				regulator-min-microvolt = <1800000>;
				regulator-max-microvolt = <1800000>;
				regulator-always-on;
			};
		};
	};

	// Codec on I2C1 (PCF8563 at 0x51 is added by i2c-rtc,pcf8563)
	fragment@2 {
		target = <&i2c1>;
		__overlay__ {
			#address-cells = <1>;
			#size-cells = <0>;
			status = "okay";

			dac3100: codec@18 {
				compatible = "ti,tlv320dac3100";
				reg = <0x18>;
				#sound-dai-cells = <0>;
				reset-gpios = <&gpio 22 1>;	// GPIO_ACTIVE_LOW

				HPVDD-supply = <&vdd_3v3_audio>;
				SPRVDD-supply = <&vdd_5v_spk>;
				SPLVDD-supply = <&vdd_5v_spk>;
				AVDD-supply = <&vdd_3v3_audio>;
				IOVDD-supply = <&vdd_3v3_audio>;
				DVDD-supply = <&vdd_1v8_audio>;

				status = "okay";
			};
		};
	};

	// HP_DET: input, internal pull off (the default pull-down on
	// GPIO17 would fight the 100k board pull-up)
	fragment@3 {
		target = <&gpio>;
		__overlay__ {
			skjar_audio_pins: skjar_audio_pins {
				brcm,pins = <17>;
				brcm,function = <0>;	// input
				brcm,pull = <0>;	// none
			};
		};
	};

	fragment@4 {
		target = <&sound>;
		sound_overlay: __overlay__ {
			compatible = "simple-audio-card";
			simple-audio-card,name = "skjar";
			simple-audio-card,format = "i2s";
			simple-audio-card,bitclock-master = <&codec_dai>;
			simple-audio-card,frame-master = <&codec_dai>;

			pinctrl-names = "default";
			pinctrl-0 = <&skjar_audio_pins>;

			// Creates the "Headphones Jack" control and enables
			// the Headphones pin only while a plug is in
			simple-audio-card,hp-det-gpios = <&gpio 17 1>;	// active low

			simple-audio-card,widgets =
				"Headphone", "Headphones",
				"Speaker", "Internal Speaker";
			simple-audio-card,routing =
				"Headphones", "HPL",
				"Headphones", "HPR",
				"Internal Speaker", "SPK";
			// "Internal Speaker Switch", muted from userspace
			// while "Headphones Jack" is on
			simple-audio-card,pin-switches = "Internal Speaker";

			status = "okay";

			simple-audio-card,cpu {
				sound-dai = <&i2s_clk_consumer>;
			};

			// MCLK from Y402. No mclk-fs: the rate is fixed and
			// the driver picks its PLL settings from this value.
			codec_dai: simple-audio-card,codec {
				sound-dai = <&dac3100>;
				system-clock-frequency = <12000000>;
			};
		};
	};

	__overrides__ {
		card-name = <&sound_overlay>, "simple-audio-card,name";
	};
};
