# Repository hringdrifi/skjar (continued)

## KiCad design hardware/pcb/skjar.kicad_pcb (continued)

Parts:
C501, C502, C503, C504, C505, C506, C507, C508, C509, C510, C511, C512, C513, C514, C515, C516, C517, C518, C519, C520, C521, C522, C523, C524, C525, C526, C527, C528, C529, C530, C531, C532, C533, C534, C535, C536, C537, C538, C539, C540, C541, C542, C544, C545: 100n; C_0603_1608Metric; LCSC C14663
C543: 10u; C_0603_1608Metric; LCSC C96446
D501, D502, D503, D504, D505, D506, D507, D508, D509, D510, D511, D512, D513, D514, D515, D516, D517, D518, D519, D520, D521, D522, D523, D524, D525, D526, D527, D528, D529, D530, D531, D532, D533, D534, D535, D536, D537, D538, D539, D540, D541, D542: 1N4148W; D_SOD-123; LCSC C81598
LED501, LED502, LED503, LED504, LED505, LED506, LED507, LED508, LED509, LED510, LED511, LED512, LED513, LED514, LED515, LED516, LED517, LED518, LED519, LED520, LED521, LED522, LED523, LED524, LED525, LED526, LED527, LED528, LED529, LED530, LED531, LED532, LED533, LED534, LED535, LED536, LED537, LED538, LED539, LED540, LED541, LED542: SK6812MINI-E; LED_SK6812MINI-E_3.2x2.8mm_P1.5mm_ReverseMount; LCSC C5149201
Q501: AO3401A; SOT-23; LCSC C15127
Q502: 2N7002; SOT-23; LCSC C8545
R501, R503: 100k; R_0603_1608Metric; LCSC C25803
R502: 10k; R_0603_1608Metric; LCSC C25804
R504: 330; R_0603_1608Metric; LCSC C23138
SW501: Esc; CPG135001S30_1U
SW502: Q; CPG135001S30_1U
SW503: W; CPG135001S30_1U
SW504: E; CPG135001S30_1U
SW505: R; CPG135001S30_1U
SW506: T; CPG135001S30_1U
SW507: Y; CPG135001S30_1U
SW508: U; CPG135001S30_1U
SW509: I; CPG135001S30_1U
SW510: O; CPG135001S30_1U
SW511: P; CPG135001S30_1U
SW512: Bksp; CPG135001S30_1U
SW513: Tab; CPG135001S30_1.25U
SW514: A; CPG135001S30_1U
SW515: S; CPG135001S30_1U
SW516: D; CPG135001S30_1U
SW517: F; CPG135001S30_1U
SW518: G; CPG135001S30_1U
SW519: H; CPG135001S30_1U
SW520: J; CPG135001S30_1U
SW521: K; CPG135001S30_1U
SW522: L; CPG135001S30_1U
SW523: Enter; CPG135001S30_1.75U
SW524: LShift; CPG135001S30_1.75U
SW525: Z; CPG135001S30_1U
SW526: X; CPG135001S30_1U
SW527: C; CPG135001S30_1U
SW528: V; CPG135001S30_1U
SW529: B; CPG135001S30_1U
SW530: N; CPG135001S30_1U
SW531: M; CPG135001S30_1U
SW532: <; CPG135001S30_1U
SW533: >; CPG135001S30_1U
SW534: ?; CPG135001S30_1.25U
SW535: LCtrl; CPG135001S30_1.25U
SW536: LGui; CPG135001S30_1U
SW537: LAlt; CPG135001S30_1.25U
SW538: Space; CPG135001S30_2.75U
SW539: Space; CPG135001S30_2.25U
SW540: RAlt; CPG135001S30_1.25U
SW541: RGui; CPG135001S30_1U
SW542: RCtrl; CPG135001S30_1.25U
U501: 74AHCT1G125; SOT-23-5; MPN SN74AHCT1G125DBVR; LCSC C7484

Connections:
+5V: C545.1, Q501.2 (S), R501.1; also elsewhere on the board
+5V_LED: C501.1, C502.1, C503.1, C504.1, C505.1, C506.1, C507.1, C508.1, C509.1, C510.1, C511.1, C512.1, C513.1, C514.1, C515.1, C516.1, C517.1, C518.1, C519.1, C520.1, C521.1, C522.1, C523.1, C524.1, C525.1, C526.1, C527.1, C528.1, C529.1, C530.1, C531.1, C532.1, C533.1, C534.1, C535.1, C536.1, C537.1, C538.1, C539.1, C540.1, C541.1, C542.1, C543.1, C544.1, LED501.3 (VDD), LED502.3 (VDD), LED503.3 (VDD), LED504.3 (VDD), LED505.3 (VDD), LED506.3 (VDD), LED507.3 (VDD), LED508.3 (VDD), LED509.3 (VDD), LED510.3 (VDD), LED511.3 (VDD), LED512.3 (VDD), LED513.3 (VDD), LED514.3 (VDD), LED515.3 (VDD), LED516.3 (VDD), LED517.3 (VDD), LED518.3 (VDD), LED519.3 (VDD), LED520.3 (VDD), LED521.3 (VDD), LED522.3 (VDD), LED523.3 (VDD), LED524.3 (VDD), LED525.3 (VDD), LED526.3 (VDD), LED527.3 (VDD), LED528.3 (VDD), LED529.3 (VDD), LED530.3 (VDD), LED531.3 (VDD), LED532.3 (VDD), LED533.3 (VDD), LED534.3 (VDD), LED535.3 (VDD), LED536.3 (VDD), LED537.3 (VDD), LED538.3 (VDD), LED539.3 (VDD), LED540.3 (VDD), LED541.3 (VDD), LED542.3 (VDD), Q501.3 (D), U501.5 (VCC)
/Keymatrix Sheet/RGB_D0: LED501.2 (DIN), R504.2
COL0: SW501.1, SW512.1, SW513.1, SW524.1, SW535.1, SW541.1, SW542.1; also elsewhere on the board
COL1: SW502.1, SW511.1, SW514.1, SW523.1, SW525.1, SW534.1, SW536.1; also elsewhere on the board
COL2: SW503.1, SW510.1, SW515.1, SW522.1, SW526.1, SW533.1, SW537.1; also elsewhere on the board
COL3: SW504.1, SW509.1, SW516.1, SW521.1, SW527.1, SW532.1, SW540.1; also elsewhere on the board
COL4: SW505.1, SW508.1, SW517.1, SW520.1, SW528.1, SW531.1, SW538.1; also elsewhere on the board
COL5: SW506.1, SW507.1, SW518.1, SW519.1, SW529.1, SW530.1, SW539.1; also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, C517.2, C518.2, C519.2, C520.2, C521.2, C522.2, C523.2, C524.2, C525.2, C526.2, C527.2, C528.2, C529.2, C530.2, C531.2, C532.2, C533.2, C534.2, C535.2, C536.2, C537.2, C538.2, C539.2, C540.2, C541.2, C542.2, C543.2, C544.2, LED501.1 (VSS), LED502.1 (VSS), LED503.1 (VSS), LED504.1 (VSS), LED505.1 (VSS), LED506.1 (VSS), LED507.1 (VSS), LED508.1 (VSS), LED509.1 (VSS), LED510.1 (VSS), LED511.1 (VSS), LED512.1 (VSS), LED513.1 (VSS), LED514.1 (VSS), LED515.1 (VSS), LED516.1 (VSS), LED517.1 (VSS), LED518.1 (VSS), LED519.1 (VSS), LED520.1 (VSS), LED521.1 (VSS), LED522.1 (VSS), LED523.1 (VSS), LED524.1 (VSS), LED525.1 (VSS), LED526.1 (VSS), LED527.1 (VSS), LED528.1 (VSS), LED529.1 (VSS), LED530.1 (VSS), LED531.1 (VSS), LED532.1 (VSS), LED533.1 (VSS), LED534.1 (VSS), LED535.1 (VSS), LED536.1 (VSS), LED537.1 (VSS), LED538.1 (VSS), LED539.1 (VSS), LED540.1 (VSS), LED541.1 (VSS), LED542.1 (VSS), Q502.2 (S), R503.2, U501.1, U501.3 (GND); also elsewhere on the board
unnamed: D501.2 (A), SW501.2
unnamed: D502.2 (A), SW502.2
unnamed: D503.2 (A), SW503.2
unnamed: D504.2 (A), SW504.2
unnamed: D505.2 (A), SW505.2
unnamed: D506.2 (A), SW506.2
unnamed: D507.2 (A), SW507.2
unnamed: D508.2 (A), SW508.2
unnamed: D509.2 (A), SW509.2
unnamed: D510.2 (A), SW510.2
unnamed: D511.2 (A), SW511.2
unnamed: D512.2 (A), SW512.2
unnamed: D513.2 (A), SW513.2
unnamed: D514.2 (A), SW514.2
unnamed: D515.2 (A), SW515.2
unnamed: D516.2 (A), SW516.2
unnamed: D517.2 (A), SW517.2
unnamed: D518.2 (A), SW518.2
unnamed: D519.2 (A), SW519.2
unnamed: D520.2 (A), SW520.2
unnamed: D521.2 (A), SW521.2
unnamed: D522.2 (A), SW522.2
unnamed: D523.2 (A), SW523.2
unnamed: D524.2 (A), SW524.2
unnamed: D525.2 (A), SW525.2
unnamed: D526.2 (A), SW526.2
unnamed: D527.2 (A), SW527.2
unnamed: D528.2 (A), SW528.2
unnamed: D529.2 (A), SW529.2
unnamed: D530.2 (A), SW530.2
unnamed: D531.2 (A), SW531.2
unnamed: D532.2 (A), SW532.2
unnamed: D533.2 (A), SW533.2
unnamed: D534.2 (A), SW534.2
unnamed: D535.2 (A), SW535.2
unnamed: D536.2 (A), SW536.2
unnamed: D537.2 (A), SW537.2
unnamed: D538.2 (A), SW538.2
unnamed: D539.2 (A), SW539.2
unnamed: D540.2 (A), SW540.2
unnamed: D541.2 (A), SW541.2
unnamed: D542.2 (A), SW542.2
unnamed: LED501.4 (DOUT), LED502.2 (DIN)
unnamed: LED502.4 (DOUT), LED503.2 (DIN)
unnamed: LED503.4 (DOUT), LED504.2 (DIN)
unnamed: LED504.4 (DOUT), LED505.2 (DIN)
unnamed: LED505.4 (DOUT), LED506.2 (DIN)
unnamed: LED506.4 (DOUT), LED507.2 (DIN)
unnamed: LED507.4 (DOUT), LED508.2 (DIN)
unnamed: LED508.4 (DOUT), LED509.2 (DIN)
unnamed: LED509.4 (DOUT), LED510.2 (DIN)
unnamed: LED510.4 (DOUT), LED511.2 (DIN)
unnamed: LED511.4 (DOUT), LED512.2 (DIN)
unnamed: LED512.4 (DOUT), LED523.2 (DIN)
unnamed: LED513.2 (DIN), LED514.4 (DOUT)
unnamed: LED513.4 (DOUT), LED524.2 (DIN)
unnamed: LED514.2 (DIN), LED515.4 (DOUT)
unnamed: LED515.2 (DIN), LED516.4 (DOUT)
unnamed: LED516.2 (DIN), LED517.4 (DOUT)
unnamed: LED517.2 (DIN), LED518.4 (DOUT)
unnamed: LED518.2 (DIN), LED519.4 (DOUT)
unnamed: LED519.2 (DIN), LED520.4 (DOUT)
unnamed: LED520.2 (DIN), LED521.4 (DOUT)
unnamed: LED521.2 (DIN), LED522.4 (DOUT)
unnamed: LED522.2 (DIN), LED523.4 (DOUT)
unnamed: LED524.4 (DOUT), LED525.2 (DIN)
unnamed: LED525.4 (DOUT), LED526.2 (DIN)
unnamed: LED526.4 (DOUT), LED527.2 (DIN)
unnamed: LED527.4 (DOUT), LED528.2 (DIN)
unnamed: LED528.4 (DOUT), LED529.2 (DIN)
unnamed: LED529.4 (DOUT), LED530.2 (DIN)
unnamed: LED530.4 (DOUT), LED531.2 (DIN)
unnamed: LED531.4 (DOUT), LED532.2 (DIN)
unnamed: LED532.4 (DOUT), LED533.2 (DIN)
unnamed: LED533.4 (DOUT), LED534.2 (DIN)
unnamed: LED534.4 (DOUT), LED542.2 (DIN)
unnamed: LED535.2 (DIN), LED536.4 (DOUT)
unnamed: LED536.2 (DIN), LED537.4 (DOUT)
unnamed: LED537.2 (DIN), LED538.4 (DOUT)
unnamed: LED538.2 (DIN), LED539.4 (DOUT)
unnamed: LED539.2 (DIN), LED540.4 (DOUT)
unnamed: LED540.2 (DIN), LED541.4 (DOUT)
unnamed: LED541.2 (DIN), LED542.4 (DOUT)
unnamed: C545.2, Q501.1 (G), R501.2, R502.2
unnamed: Q502.3 (D), R502.1
unnamed: R504.1, U501.4
RGB_DATA: U501.2; also elsewhere on the board
RGB_EN: Q502.1 (G), R503.1; also elsewhere on the board
ROW0: D501.1 (K), D502.1 (K), D503.1 (K), D504.1 (K), D505.1 (K), D506.1 (K); also elsewhere on the board
ROW1: D507.1 (K), D508.1 (K), D509.1 (K), D510.1 (K), D511.1 (K), D512.1 (K); also elsewhere on the board
ROW2: D513.1 (K), D514.1 (K), D515.1 (K), D516.1 (K), D517.1 (K), D518.1 (K); also elsewhere on the board
ROW3: D519.1 (K), D520.1 (K), D521.1 (K), D522.1 (K), D523.1 (K), D542.1 (K); also elsewhere on the board
ROW4: D524.1 (K), D525.1 (K), D526.1 (K), D527.1 (K), D528.1 (K), D529.1 (K); also elsewhere on the board
ROW5: D530.1 (K), D531.1 (K), D532.1 (K), D533.1 (K), D534.1 (K), D541.1 (K); also elsewhere on the board
ROW6: D535.1 (K), D536.1 (K), D537.1 (K), D538.1 (K), D539.1 (K), D540.1 (K); also elsewhere on the board

Notes on the sheet:
データ（RGB_D0）が流れる順に並べている。基板上の並びは hardware/layout/README.md。LED501〜LED542 はすべて SK6812MINI-E。
キーの RGB：LED の電源の ON / OFF とデータのバッファ
LED のパスコン（各 LED に 100 nF ×1。基板では各 LED の隣に置く）
キーの RGB（SK6812MINI-E ×42）。詳細は docs/schematic/keymatrix.md
キーマトリクス（7 行 × 6 列、COL2ROW。対応は hardware/layout/README.md）

Parts:
C101, C102, C103, C104, C105, C106, C107, C111, C112, C115: 100n; C_0603_1608Metric; LCSC C14663
C109, C110: 1u; C_0603_1608Metric; LCSC C15849
C113, C114: 27p; C_0603_1608Metric; LCSC C107045
J101: SWD; PinHeader_1x05_P1.27mm_Holes
R101, R102, R107, R108, R109, R110: 1k; R_0603_1608Metric; LCSC C21190
R103: 10k; R_0603_1608Metric; LCSC C25804
R105, R106: 27; R_0603_1608Metric; LCSC C25190
SW101: BOOTSEL; SW_Push_1P1T_XKB_TS-1187A; LCSC C318884
TP101: KB_SDA; TestPoint_Pad_D1.5mm
TP102: KB_SCL; TestPoint_Pad_D1.5mm
TP103: KB_INT; TestPoint_Pad_D1.5mm
U101: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm; LCSC C2040
U102: W25Q128JVPIQ; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm; LCSC C190862
Y101: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN XXHBBCNANF-12.000000MHZ; LCSC C521581

Connections:
+1V1: C110.1, C111.1, C112.1, U101.23 (DVDD), U101.45 (VREG_VOUT), U101.50 (DVDD)
+3V3: C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C109.1, C115.1, J101.1, R103.1, U101.1 (IOVDD), U101.10 (IOVDD), U101.22 (IOVDD), U101.33 (IOVDD), U101.42 (IOVDD), U101.43 (ADC_AVDD), U101.44 (VREG_VIN), U101.48 (USB_VDD), U101.49 (IOVDD), U102.8 (VCC); also elsewhere on the board
/RP2040 Sheet/QSPI_SCLK: U101.52 (QSPI_SCLK), U102.6 (CLK)
/RP2040 Sheet/QSPI_SD0: U101.53 (QSPI_SD0), U102.5 (DI/IO_{0})
/RP2040 Sheet/QSPI_SD1: U101.55 (QSPI_SD1), U102.2 (DO/IO_{1})
/RP2040 Sheet/QSPI_SD2: U101.54 (QSPI_SD2), U102.3 (~WP/IO_{2})
/RP2040 Sheet/QSPI_SD3: U101.51 (QSPI_SD3), U102.7 (~HOLD/~RESET/IO_{3})
/RP2040 Sheet/RUN: J101.5, R103.2, U101.26 (RUN)
/RP2040 Sheet/SWCLK: J101.2, U101.24 (SWCLK)
/RP2040 Sheet/SWDIO: J101.4, U101.25 (SWDIO)
/RP2040 Sheet/USB_DN: R106.1, U101.46 (USB_DM)
/RP2040 Sheet/USB_DP: R105.1, U101.47 (USB_DP)
/RP2040 Sheet/~QSPI_SS: SW101.1, U101.56 (~QSPI_SS), U102.1 (~CS)
BOOT_EN: U101.8 (GPIO6); also elsewhere on the board
CC1_A: R107.1; also elsewhere on the board
CC1_B: R109.1; also elsewhere on the board
CC2_A: R108.1; also elsewhere on the board
CC2_B: R110.1; also elsewhere on the board
CM0_HALT: U101.9 (GPIO7); also elsewhere on the board
CM0_PWROFF: U101.7 (GPIO5); also elsewhere on the board
CM0_RUN_PG: U101.11 (GPIO8); also elsewhere on the board
CM0_TXD: U101.3 (GPIO1); also elsewhere on the board
COL0: U101.34 (GPIO22); also elsewhere on the board
COL1: U101.18 (GPIO15); also elsewhere on the board
COL2: U101.14 (GPIO11); also elsewhere on the board
COL3: U101.15 (GPIO12); also elsewhere on the board
COL4: U101.16 (GPIO13); also elsewhere on the board
COL5: U101.17 (GPIO14); also elsewhere on the board
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, J101.3, R102.2, U101.19 (TESTEN), U101.57 (GND), U102.4 (GND), U102.9 (GND), Y101.2 (G), Y101.4 (G); also elsewhere on the board
KB_INT: TP103.1 (1_1), U101.13 (GPIO10); also elsewhere on the board
KB_SCL: TP102.1 (1_1), U101.12 (GPIO9); also elsewhere on the board
KB_SDA: TP101.1 (1_1), U101.6 (GPIO4); also elsewhere on the board
LCD_EN: U101.4 (GPIO2); also elsewhere on the board
unnamed: C114.1, R101.1, Y101.3
unnamed: R102.1, SW101.2
unnamed: R107.2, U101.38 (GPIO26/ADC0)
unnamed: R108.2, U101.39 (GPIO27/ADC1)
unnamed: R109.2, U101.40 (GPIO28/ADC2)
unnamed: R110.2, U101.41 (GPIO29/ADC3)
unnamed: C113.1, U101.20 (XIN), Y101.1
unnamed: R101.2, U101.21 (XOUT)
PWR_ST: U101.5 (GPIO3); also elsewhere on the board
RGB_DATA: U101.28 (GPIO17); also elsewhere on the board
RGB_EN: U101.27 (GPIO16); also elsewhere on the board
ROW0: U101.37 (GPIO25); also elsewhere on the board
ROW1: U101.29 (GPIO18); also elsewhere on the board
ROW2: U101.36 (GPIO24); also elsewhere on the board
ROW3: U101.30 (GPIO19); also elsewhere on the board
ROW4: U101.35 (GPIO23); also elsewhere on the board
ROW5: U101.31 (GPIO20); also elsewhere on the board
ROW6: U101.32 (GPIO21); also elsewhere on the board
RP_TXD: U101.2 (GPIO0); also elsewhere on the board
USB_A_D+: R105.2; also elsewhere on the board
USB_A_D-: R106.2; also elsewhere on the board

Notes on the sheet:
テストパッド
キーボードのコントローラ。キーマトリクスと RGB を受け持ち、PC へは Port A の USB HID、CM0 へは I²C（KB_SDA / KB_SCL / KB_INT）で送る。 CM0 の電源（CM0_PWROFF → GLOBAL_EN）と起動モード（BOOT_EN → nRPI_BOOT）も RP2040 が操作する。 CC1_A〜CC2_B は 1 kΩ を通して ADC へ（PC がつながっているかの判定）。 ファームは BOOTSEL を押しながら Port A から UF2 で書き込む。SWD はテストパッドだけ。 詳細：docs/schematic/rp2040.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
BOOTSEL（UF2）
QSPI フラッシュ

Parts:
C301: 100n; C_0603_1608Metric; LCSC C14663
J301: DSI FPC 22P 0.5mm; Hirose_FH12-22S-0.5SH_1x22-1MP_P0.50mm_Horizontal; LCSC C597981
J302: LCD 5V (5V/5V/GND); PinHeader_1x03_P2.54mm_Horizontal

Connections:
+3V3_CM0: C301.1, J301.1; also elsewhere on the board
+5V_LCD: J302.1, J302.2; also elsewhere on the board
DSI_CK_N: J301.15; also elsewhere on the board
DSI_CK_P: J301.14; also elsewhere on the board
DSI_D0_N: J301.21; also elsewhere on the board
DSI_D0_P: J301.20; also elsewhere on the board
DSI_D1_N: J301.18; also elsewhere on the board
DSI_D1_P: J301.17; also elsewhere on the board
DSI_D2_N: J301.12; also elsewhere on the board
DSI_D2_P: J301.11; also elsewhere on the board
DSI_D3_N: J301.9; also elsewhere on the board
DSI_D3_P: J301.8; also elsewhere on the board
GND: C301.2, J301.4, J301.7, J301.10, J301.13, J301.16, J301.19, J301.22, J302.3; also elsewhere on the board
I2C_DSI_SCL: J301.3; also elsewhere on the board
I2C_DSI_SDA: J301.2; also elsewhere on the board

Notes on the sheet:
LCD の電源（ライトアングル 1x3、5V / 5V / GND）
DSI（22 ピン FPC、Raspberry Pi 5 と同じピン配置）
J301 のピン番号は Raspberry Pi 5 / CM4 と同じ順。付属の FFC（両端で接点の向きが逆）で、基板の n 番がパネルの 23 − n 番につながる。 片面接点（上接点）の Hirose FH12A を使い、逆向きには接点が当たらないようにしている。 詳細：docs/schematic/display.md

Parts:
BT401: CR2032; BatteryHolder_MYOUNG_MY-2032-08; LCSC C964831
C401, C403, C404, C406, C407, C409, C411, C414, C415: 100n; C_0603_1608Metric; LCSC C14663
C402: 22u; C_0805_2012Metric; LCSC C45783
C405, C408, C410: 10u; C_0603_1608Metric; LCSC C96446
C412, C413: 220u; CP_Elec_6.3x7.7; LCSC C970695
D401: BAT54C; SOT-23
FB401: 600R; L_0805_2012Metric; LCSC C1017
J401: Speaker; Molex_PicoBlade_53261-0271_1x02-1MP_P1.25mm_Horizontal; LCSC C177225
J402: PJ-320D-4A; Jack_3.5mm_KoreanHropartsElec_PJ-320D-4A_Horizontal; LCSC C95562
MK401: ICS-43434; InvenSense_ICS-43434-6_3.5x2.65mm; LCSC C5656610
R401, R404, R405: 10k; R_0603_1608Metric; LCSC C25804
R403, R406, R407: 100k; R_0603_1608Metric; LCSC C25803
U401: PCF8563T; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C7440
U402: TLV320DAC3100; Texas_RHB0032E_VQFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm; MPN TLV320DAC3100IRHBR; LCSC C179677
Y401: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm; LCSC C479190
Y402: 12MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; MPN OT2EL89CJI-111YLC-12M; LCSC C5280582

Connections:
+1V8_CM0: C408.1, C409.1, U402.3 (DVDD); also elsewhere on the board
+3V3: D401.1; also elsewhere on the board
+3V3_CM0: C410.1, C411.1, C414.1, C415.1, FB401.1, MK401.5 (VDD), R401.1, R403.1, U402.2 (IOVDD), Y402.1 (EN), Y402.4 (Vdd); also elsewhere on the board
+5V: C402.1, C403.1, C404.1, U402.21 (SPKVDD), U402.24 (SPKVDD); also elsewhere on the board
/Peripherals Sheet/HPL_OUT: C412.1, U402.27 (HPL)
/Peripherals Sheet/HPR_OUT: C413.1, U402.30 (HPR)
/Peripherals Sheet/JACK_L: C412.2, J402.T, R404.1
/Peripherals Sheet/JACK_R: C413.2, J402.R1, R405.1
AVDD_CODEC: C405.1, C406.1, C407.1, FB401.2, U402.17 (AVDD), U402.28 (HPVDD)
CODEC_RST: R406.1, U402.31 (~RESET); also elsewhere on the board
GND: BT401.2 (-), C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C414.2, C415.2, J402.R2, MK401.2 (LR), MK401.3 (GND), R404.2, R405.2, R406.2, R407.2, U401.4 (VSS), U402.1 (IOVSS), U402.16 (AVSS), U402.18 (DVSS), U402.20 (SPKVSS), U402.25 (SPKVSS), U402.29 (HPVSS), U402.33 (PAD), Y402.2 (GND); also elsewhere on the board
HP_DET: J402.S, R403.2; also elsewhere on the board
I2C1_SCL: U401.6 (SCL), U402.10 (SCL); also elsewhere on the board
I2C1_SDA: U401.5 (SDA), U402.9 (SDA); also elsewhere on the board
I2S_BCLK: MK401.4 (SCK), U402.7 (BCLK); also elsewhere on the board
I2S_DIN: MK401.6 (SD), R407.1; also elsewhere on the board
I2S_DOUT: U402.5 (DIN); also elsewhere on the board
I2S_LRCLK: MK401.1 (WS), U402.6 (WCLK); also elsewhere on the board
unnamed: J401.1, U402.22 (SPKP), U402.26 (SPKP)
unnamed: J401.2, U402.19 (SPKM), U402.23 (SPKM)
unnamed: U401.1 (OSCI), Y401.1
unnamed: U401.2 (OSCO), Y401.2
unnamed: U402.8 (MCLK), Y402.3 (OUT)
RTC_INT: R401.2, U401.3 (~INT); also elsewhere on the board
VBAT: BT401.1 (+), D401.2
VDD_RTC: C401.1, D401.3, U401.8 (VDD)

Notes on the sheet:
音声（TLV320DAC3100）
RTC は +3V3（常時 ON）と CR2032 の高い方から BAT54C で給電する。CM0 が OFF でも時刻を保つ。 I2C1 のプルアップは CM0 の内部（1.8 kΩ）を使う。 音声 IC は SPKVDD だけ +5V、ほかは CM0 の 3.3 V / 1.8 V から取り、CM0 と一緒に ON / OFF する（データシートの推奨順序に合う）。 詳細：docs/schematic/peripherals.md
RTC（PCF8563T + CR2032）
マイク（ICS-43434）
